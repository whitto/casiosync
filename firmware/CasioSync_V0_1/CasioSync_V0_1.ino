// CasioSync_V0_1.ino
// V0.1 R3 - 13 October 2026 (Australia/Brisbane)
// - Complete host-test mocks for the retained configuration transaction.
// - Hash only publishable sources in board package manifests; exclude ignored builds.
// - Retain README watch/alarm screenshots and immutable board download ZIP tags.
// - No Bluetooth, scheduling, Wi-Fi or storage runtime behavior changes.
//
// V0.1 R2 - 13 October 2026 (Australia/Brisbane)
//   - Fix watch-options test syntax; match the unavailable-feature UI test to hidden controls.
//   - Board-specific GitHub ZIP tags provide compiled downloads when asset upload is rejected.
//   - Firmware behavior/dependencies unchanged; both target packages rebuilt for R2 labels.
// V0.1 R1 - 13 October 2026 (Australia/Brisbane)
//   - Casio-only fork of time-transmitter V4.16 R1; all LF transmitters removed.
//   - Preserve GW-BX5600 packet exchanges, font/battery reads and watch binding.
//   - Preserve independent BT and Wi-Fi schedules, checked provisioning and NTP trust.
//   - Keep fixed RAM history, BT-only 24-hour LED and optional first-success daily snapshot.
//   - Casio-only CRC settings and separate files never interpret transmitter settings.
//   - Bounded BLE scan/client shutdown, HTTP parsing and loop progress supervision.
//   - 122 model protocol candidates; 119 optional-setting capability templates.
//   - Opt-in per-watch alarms, chime, countdown, basic settings and auto adjustment.
//   - Apply selective merges/readback before TIME; saved choices bound to watch identity.
//   - Compiled Node32s/C3 SuperMini; core 3.3.12, CrashDumpGate 1.0.1 adds C3 metadata.
// Original project ancestry credits: (c) 2021 taroh (sasaki.taroh@gmail.com),
// (c) 2025 5Breeze (bitshen@qq.com); CasioSync development by whitto.
// Casio BLE protocol sources and licenses are documented in README.md/CREDITS.md.
//   - Exact Casio model catalogue; corrected Standard 11-byte TIME framing from captures.
// Project: https://github.com/whitto/casiosync

// Arduino's board variant supplies RGB_BUILTIN/LED_BUILTIN for ESP32-C3.
// The generic ESP32-C3 target uses an addressable RGB LED; drive only blue.
#if defined(CONFIG_IDF_TARGET_ESP32C3) && defined(CASIOSYNC_C3_SUPERMINI)
  #define PIN_ONBOARD_LED (8) // ESP32-C3 SuperMini discrete blue LED.
  #define ACTIVITY_LED_ACTIVE_LOW 1
#elif defined(CONFIG_IDF_TARGET_ESP32C3) && defined(RGB_BUILTIN)
  #define ACTIVITY_LED_RGB_PIN RGB_BUILTIN
#elif defined(CONFIG_IDF_TARGET_ESP32C3) && defined(LED_BUILTIN)
  #define PIN_ONBOARD_LED LED_BUILTIN
#elif defined(CONFIG_IDF_TARGET_ESP32C3)
  #define ACTIVITY_LED_UNAVAILABLE 1 // No guessed GPIO is driven.
#else
  #define PIN_ONBOARD_LED (2) // Node32s blue activity LED, active HIGH.
#endif

// Library Includes
#include <WiFi.h>           // WiFi connectivity
#include <RadioBoundedWebServer.h> // Pinned 3.3.12 parser with request size/time bounds
#if !defined(RADIO_HTTP_BOUNDS_VERSION) || RADIO_HTTP_BOUNDS_VERSION != 1
#error "Install the included RadioBoundedWebServer library for bounded HTTP request parsing"
#endif
#include <LittleFS.h>        // File system for configuration storage (see initFilesystem())
#include <RadioCrashDumpGate.h> // Saved, default-Off control of SDK panic dumps.
// BLE central stack. NimBLE-Arduino 2.5.1+ substantially reduces
// flash/RAM use while retaining the Casio client protocols.
#include <NimBLEDevice.h>
#if !defined(NIMBLE_RADIOCLOCK_RELIABILITY_PATCH) || NIMBLE_RADIOCLOCK_RELIABILITY_PATCH != 1
#error "Install the bundled NimBLE-Arduino 2.5.1-radioclock.1 source library; ordinary 2.5.1 has an unsafe host-stop timer."
#endif
#include <NimBLEUtils.h>
#ifdef USING_NIMBLE_ARDUINO_HEADERS
#include "nimble/porting/nimble/include/nimble/nimble_port.h"
#else
#include "nimble/nimble_port.h"
#endif

#include "CasioBleScanControl.h"
#include "CasioBxProtocol.h"
#include "CasioWatchSettings.h"
#include "CasioWatchBattery.h"
#include "BtSyncLed.h"
#include "BtSyncHistory.h"
#include "BtRecentSyncs.h"
#include "CasioWifiAccessWindow.h"
#include "CasioJsonWriter.h"
#include "CasioConfigWriter.h"
#include "esp_bt.h"
#include "esp_system.h"
#include "esp_heap_caps.h"
#include "esp_mac.h"
#include <atomic>
#include <string>
#include "CasioModelCatalog.h"
#include "CasioStandardProtocol.h"
#include "CasioWatchFeatures.h"
#include "CasioWatchOptions.h"
#include <strings.h>
#include <ArduinoJson.h>    // JSON parsing and generation
#include <time.h>
#include <sys/time.h>
#include "esp_sntp.h"
#include "esp_timer.h"
#include <math.h>

// Global Objects
RadioBoundedWebServer server(80); // Existing routes, bounded HTTP receive on port 80
bool webRoutesRegistered=false;
bool webServerStarted=false;

// Configuration Constants
#define DEVICENAME_PREFIX "CasioSync"     // Device name prefix for WiFi AP mode
#define FIRMWARE_VERSION "V0.1"
#define FIRMWARE_BUILD "R3"

#define DEFAULT_TZ_NAME "Australia/Brisbane"
#define CONFIG_FILE "/casiosync-config.txt"           // WiFi and timezone configuration file
#define CONFIG_TEMP_FILE "/casiosync-config.tmp"

// WiFi Configuration Variables
char ssid[64] = "";                          // WiFi SSID (network name)
char passwd[64] = "";                        // WiFi password
String timezone_name = DEFAULT_TZ_NAME;           // IANA timezone name
#define DEFAULT_BT_TIMEZONE "Australia/Brisbane"
String btTimezoneName = DEFAULT_BT_TIMEZONE;     // Independent civil time zone used only for BLE watch writes.
int btTimeOffsetMinutes = 0;                     // Additional offset applied to watch time and BT schedules.
unsigned long wifi_connect_start = 0;        // Timestamp when WiFi connection started
#define WIFI_CONNECT_TIMEOUT 30000           // WiFi connection timeout: 30 seconds
#define WIFI_CONNECT_CHECK_INTERVAL 250      // Nonblocking association supervision: 250 ms

// LoopTask owns settings, API responses and Bluetooth work. Only fixed snapshots
// cross to SDK callbacks; the monitor observes a 64-bit monotonic heartbeat.
static void applyTimezone(void);
static void sendIndexPage(void);
void updateWifiPowerManagement(void);
static bool configureNtpClient(void);
static void beginWifiCredentialConnection(void);
static void flushNtpLogs(void);
bool writeConfigNow(void);
void normalizeBluetoothSlots(void);
std::atomic<int> ntpsync{0};
portMUX_TYPE progressMux = portMUX_INITIALIZER_UNLOCKED;
uint64_t applicationLoopLastUs = 0;
std::atomic<uint32_t> loopStackMinimum{UINT32_MAX};
std::atomic<uint32_t> monitorStackMinimum{UINT32_MAX};
TaskHandle_t safetyMonitorTaskHandle = nullptr;
std::atomic<bool> safetyMonitorReady{false};
static constexpr uint64_t LOOP_PROGRESS_DEADLINE_US = 70000000ULL;
void applicationForceSafeRestart(void) { esp_restart(); }
static uint32_t progressAgeMs(uint64_t lastUs) {
  const uint64_t nowUs = (uint64_t)esp_timer_get_time();
  if (!lastUs || nowUs < lastUs) return UINT32_MAX;
  const uint64_t ageMs = (nowUs - lastUs) / 1000ULL;
  return ageMs > UINT32_MAX ? UINT32_MAX : (uint32_t)ageMs;
}
uint32_t applicationLoopAgeMs(void) {
  portENTER_CRITICAL(&progressMux);
  const uint64_t last = applicationLoopLastUs;
  portEXIT_CRITICAL(&progressMux);
  return progressAgeMs(last);
}
uint32_t applicationLoopStackMinimum(void) { const uint32_t n=loopStackMinimum.load(); return n==UINT32_MAX?0:n; }
uint32_t safetyMonitorStackMinimum(void) { const uint32_t n=monitorStackMinimum.load(); return n==UINT32_MAX?0:n; }
void applicationProgressCheckpoint(void) {
  const uint64_t nowUs = (uint64_t)esp_timer_get_time();
  portENTER_CRITICAL(&progressMux);
  applicationLoopLastUs = nowUs;
  portEXIT_CRITICAL(&progressMux);
  static uint64_t lastStackCheckUs = 0;
  if (nowUs - lastStackCheckUs >= 1000000ULL) {
    lastStackCheckUs = nowUs;
    const uint32_t available = (uint32_t)uxTaskGetStackHighWaterMark(nullptr);
    if (available < loopStackMinimum) loopStackMinimum = available;
  }
}

// --- Adaptive NTP resync interval ---
// Rather than resyncing on a fixed schedule, this measures how much the
// board's own clock actually drifts between syncs and shortens/lengthens
// the resync interval to match - a board with a more accurate crystal gets
// resynced less often (saving a WiFi/NTP round-trip), a drifty one gets
// resynced more often, and either way the clock stays within roughly
// NTP_ERROR_BUDGET_SEC seconds of correct between syncs. See onNtpSync()
// (measures the drift on every successful sync) and configureAdaptiveNtp()
// (sets the interval before SNTP schedules its next request).
portMUX_TYPE clockMux = portMUX_INITIALIZER_UNLOCKED;
uint64_t ntpLastMonoUs = 0;         // esp_timer (monotonic) time at the previous sync, microseconds
int64_t ntpLastEpochUs = 0;         // Wall-clock (epoch) time at the previous sync, microseconds
double ntpDriftPpm = 0.0;           // Smoothed clock drift estimate, parts-per-million
double ntpDriftAbsSecPerHour = 0.0; // Same drift, expressed as seconds/hour (for logging/diagnostics)
// Validity comes ONLY from the SNTP callback, not a plausible clock year.
// A conservative 50 ppm estimate is used until real drift samples exist.
static const double CLOCK_INITIAL_PPM = 50.0;
static const uint32_t CLOCK_MAX_HOLDOVER_SEC = 21600UL;
static const double CLOCK_INITIAL_UNCERTAINTY_SEC = 0.20;
std::atomic<uint32_t> ntpIntervalSec{3600};
static bool clockNtpEverSynced = false;
static uint32_t clockNtpSyncCount = 0;
static bool clockDriftSampleAvailable = false;
static double clockDriftBoundPpm = CLOCK_INITIAL_PPM; // Absolute envelope: opposite signs cannot cancel.
static bool clockNtpRejected = false;
static uint32_t clockNtpRejectedCount = 0;
static const double CLOCK_DRIFT_FLOOR_PPM = 5.0;
static const double CLOCK_MAX_PLAUSIBLE_PPM = 1000.0;
// Provisional acquisition is RAM only. A single plausible year is never a
// time anchor: require three advancing replies over at least 30 seconds.
static uint64_t ntpCandidateMonoUs = 0, ntpCandidateLastMonoUs = 0;
static int64_t ntpCandidateEpochUs = 0;
static uint8_t ntpCandidateReplies = 0;
static uint8_t clockNtpCandidateReplyCount = 0; // clockMux-protected diagnostic snapshot.
static uint32_t clockNtpReacquisitionCount = 0;
static uint64_t ntpDriftAnchorMonoUs = 0;
static int64_t ntpDriftAnchorEpochUs = 0;
static const uint64_t NTP_CANDIDATE_MIN_STEP_US = 10000000ULL;
static const uint64_t NTP_CANDIDATE_MIN_SPAN_US = 30000000ULL;
static const uint64_t NTP_CANDIDATE_MAX_SPAN_US = 600000000ULL;
uint64_t monotonicUptimeSeconds() { return (uint64_t)esp_timer_get_time() / 1000000ULL; }
uint32_t clockAgeSeconds() {
  portENTER_CRITICAL(&clockMux);
  bool valid=clockNtpEverSynced;
  uint64_t snapshot=ntpLastMonoUs;
  portEXIT_CRITICAL(&clockMux);
  if (!valid || !snapshot) return UINT32_MAX;
  int64_t age = esp_timer_get_time() - (int64_t)snapshot;
  if (age < 0 || (uint64_t)age / 1000000ULL >= UINT32_MAX) return UINT32_MAX;
  return (uint32_t)((uint64_t)age / 1000000ULL);
}
double clockEstimatedError() {
  uint32_t age = clockAgeSeconds();
  if (age == UINT32_MAX) return 9999.0;
  portENTER_CRITICAL(&clockMux);
  const double ppm=clockDriftBoundPpm;
  portEXIT_CRITICAL(&clockMux);
  return CLOCK_INITIAL_UNCERTAINTY_SEC + ppm * (double)age / 1000000.0;
}
const char *clockConfidence() {
  uint32_t age = clockAgeSeconds();
  portENTER_CRITICAL(&clockMux);
  const bool rejected=clockNtpRejected;
  portEXIT_CRITICAL(&clockMux);
  if (rejected || age == UINT32_MAX || age > CLOCK_MAX_HOLDOVER_SEC || clockEstimatedError() > 0.90) return "Unsynchronized";
  return age <= ntpIntervalSec ? "Synchronized" : "Holdover";
}
bool clockTrusted() { return strcmp(clockConfidence(), "Unsynchronized") != 0; }
#define NTP_INITIAL_INTERVAL_SEC 3600UL   // Resync interval before any drift has been measured yet
#define NTP_MIN_INTERVAL_SEC 15UL         // SNTP/RFC minimum; large drift must not force a 15-minute loss of trust
#define NTP_ERROR_BUDGET_SEC 0.90          // Total error budget, including initial sync uncertainty
#define NTP_RESYNC_MARGIN 0.90            // Request again before either the error or six-hour trust limit
#define NTP_DRIFT_EMA_ALPHA 0.35          // Smoothing factor (0-1) for the drift estimate; higher = reacts faster to new measurements, lower = more stable against noisy single measurements

//...................................................................
// Casio BLE time-only profiles. Values are persisted: do not reorder.
// 0: GW-BX5600 MIP with the model-specific four-step SP handshake.
// 1: Standard digital / hybrid (11-byte current-time write).
// 2: Analogue/MT-G experimental time-only (same inherited standard time write;
//    motor/second-dial setup is intentionally never written).
// Do not send MIP packets to other MIP models without validating their handshake.
enum CasioBleProtocol : uint8_t {
  BT_PROTOCOL_BX5600_MIP = 0,
  BT_PROTOCOL_STANDARD = 1,
  BT_PROTOCOL_ANALOGUE = 2,
  BT_PROTOCOL_COUNT = 3
};
static bool validBtProtocol(int p) { return p >= 0 && p < BT_PROTOCOL_COUNT; }
static const char *btProtocolName(int p) {
  switch (p) {
    case BT_PROTOCOL_BX5600_MIP: return "GW-BX5600 MIP";
    case BT_PROTOCOL_STANDARD: return "Standard digital/hybrid";
    case BT_PROTOCOL_ANALOGUE: return "Analogue time-only (experimental)";
    default: return "Unknown Casio protocol";
  }
}

// Casio GW-BX5600 BLE time synchronization
// Watch-initiated connection model: the ESP32 opens a scan window and
// waits for the watch to advertise its Casio Bluetooth service.
#define CASIO_ADVERTISEMENT_SERVICE "1804"
#define CASIO_WATCH_FEATURES_SERVICE "26eb000d-b012-49a8-b1f8-394fb2032b0f"
#define CASIO_SP_REQUEST_CHAR       "26eb002e-b012-49a8-b1f8-394fb2032b0f"
#define CASIO_SP_DATA_CHAR          "26eb002f-b012-49a8-b1f8-394fb2032b0f"
#define CASIO_SET_CHAR              "26eb002d-b012-49a8-b1f8-394fb2032b0f"
#define CASIO_BASIC_REQUEST_CHAR    "26eb002c-b012-49a8-b1f8-394fb2032b0f"

#define BT_SYNC_SLOT_COUNT 4
#define BT_PREPARE_MINUTES 5
#define BT_WINDOW_AFTER_MINUTES 5
#define BT_MANUAL_WINDOW_MINUTES 7
#define BT_REQUEST_TIMEOUT_MS 5000UL
#define BT_SCAN_SLICE_MS 1000UL

int btSyncTimes[BT_SYNC_SLOT_COUNT] = {30, 390, 750, 1110}; // 00:30, 06:30, 12:30, 18:30
bool btSyncEnabled[BT_SYNC_SLOT_COUNT] = {true, true, true, true};
uint8_t btSyncProtocol[BT_SYNC_SLOT_COUNT] = {BT_PROTOCOL_BX5600_MIP, BT_PROTOCOL_BX5600_MIP,
                                            BT_PROTOCOL_BX5600_MIP, BT_PROTOCOL_BX5600_MIP};
uint8_t btManualProtocol = BT_PROTOCOL_BX5600_MIP;
uint8_t btActiveProtocol = BT_PROTOCOL_BX5600_MIP;
#define BT_WATCH_PROFILE_COUNT 4
uint8_t btSyncProfile[BT_SYNC_SLOT_COUNT] = {0,0,0,0};
uint8_t btManualProfile = 0;
uint8_t btActiveProfile = 0;
int btProfileSuccessYear[BT_WATCH_PROFILE_COUNT] = {-1,-1,-1,-1};
int btProfileSuccessYday[BT_WATCH_PROFILE_COUNT] = {-1,-1,-1,-1};
String btProfileAddress[BT_WATCH_PROFILE_COUNT]; // Learned watch address; may change with BLE privacy.
String btProfileName[BT_WATCH_PROFILE_COUNT];
uint8_t btProfileProtocol[BT_WATCH_PROFILE_COUNT] = {0,0,0,0};
uint8_t btFontMode[BT_WATCH_PROFILE_COUNT] = {0,0,0,0}; // 0=keep, 1=Standard/new, 2=Classic
uint8_t btLastWatchAddressType = 0xFF;
uint32_t btConnectionAttempts = 0;
uint32_t btWriteAcknowledgements = 0;
std::atomic<uint32_t> btNotifications{0};
std::atomic<uint32_t> btResponseErrors{0};
const char *btDeliveryEvidence = "No delivery yet";
static void bluetoothLocalTime(time_t utc, struct tm &out);
bool btProfileDoneToday(int profile) {
  if (profile < 0 || profile >= BT_WATCH_PROFILE_COUNT) return false;
  time_t now = time(nullptr); struct tm day; bluetoothLocalTime(now, day);
  return btProfileSuccessYear[profile] == day.tm_year + 1900 &&
         btProfileSuccessYday[profile] == day.tm_yday;
}
// Circular distance between two clock times: handles midnight rollover.
int btCircularDistance(int a, int b) { int d = abs(a-b); return d < 720 ? d : 1440-d; }
bool btOverlapsOtherEnabledSlot(int slot,int minute) {
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i)
    if (i!=slot && btSyncEnabled[i] && btCircularDistance(btSyncTimes[i],minute) <=
        BT_PREPARE_MINUTES + BT_WINDOW_AFTER_MINUTES + 1) return true;
  return false;
}
// Delivery history is per protocol/profile and informational. Each enabled
// automatic slot listens every day, including after an earlier delivery.
int btSuccessYear[BT_PROTOCOL_COUNT] = {-1, -1, -1};
int btSuccessYday[BT_PROTOCOL_COUNT] = {-1, -1, -1};
bool btSyncDayComplete = false;
int btSyncLastYear = -1;
int btSyncLastYday = -1;
int btSyncActiveSlot = -1;
unsigned long btWindowEndMillis = 0;
int btSlotAttemptYear[BT_SYNC_SLOT_COUNT] = {-1,-1,-1,-1};
int btSlotAttemptYday[BT_SYNC_SLOT_COUNT] = {-1,-1,-1,-1};
std::atomic<bool> btWindowActive{false};
bool btManualSyncRequested = false;
// When enabled, CasioSync continuously scans for the already-paired selected
// watch whenever listening is enabled. Pairing itself always remains an explicit action.
bool btAlwaysWaitEnabled = true;
bool btIdlePowerSaveEnabled = false;
bool btPersistentWaitActive = false;
// This flag represents failed/required BLE shutdown only. SDK callbacks and
// synchronous GATT cancellation share it without touching settings or Strings.
std::atomic<bool> btShutdownRequested{false};
std::atomic<bool> btControllerStarted{false}; // Remains true until the controller is verified idle.
// Pair mode deliberately ignores the currently learned address for the selected
// profile, but does not erase that binding until the new watch has completed a
// successful connection/time write. This makes a failed re-pair attempt safe.
bool btPairRequested = false;
bool btPairModeActive = false;
bool btBleInitialized = false;
std::atomic<bool> btBleBusy{false};
String btLastWatchName = "";
String btLastWatchAddress = "";
String btLastSyncStatus = "Never synced";
String btLastSyncDate = "";
String btFontLastStatus = "No font override requested";
// Battery samples are runtime status only: never serialize them to LittleFS.
CasioWatchBattery::Reading btBatteryReadings[BT_WATCH_PROFILE_COUNT];
static_assert(BtRecentSyncs::ProfileCount == BT_WATCH_PROFILE_COUNT, "Recent sync profile count mismatch");
static_assert(BtRecentSyncs::ProtocolCount == BT_PROTOCOL_COUNT, "Recent sync protocol count mismatch");
BtRecentSyncs::Store btRecentSyncs; // Fixed four attempts per watch; RAM-only, cleared at boot.
const char *btBatteryStatuses[BT_WATCH_PROFILE_COUNT] = {
  "Not read since boot", "Not read since boot", "Not read since boot", "Not read since boot"
};
CasioWatchBattery::Reading btPendingBattery;
const char *btPendingBatteryStatus = "Not read during this sync";
std::atomic<uint32_t> btLastSyncEpoch{0};
std::atomic<bool> btLastOutcomeSuccessful{false};
uint32_t btProtocolLastSyncEpoch[BT_PROTOCOL_COUNT] = {};
uint32_t btProfileLastSyncEpoch[BT_WATCH_PROFILE_COUNT] = {};
uint8_t btProfileLastSyncProtocol[BT_WATCH_PROFILE_COUNT] = {};
String btProfileLastSyncAddress[BT_WATCH_PROFILE_COUNT];
bool btHistoryPersistEnabled = true;
uint32_t btHistoryGeneration = 0;
int64_t btHistorySavedDay = -1;
int64_t btHistoryAttemptDay = -1;
uint32_t btHistorySavedEpoch = 0;
uint32_t btHistorySnapshotGeneration = 0;
String btHistorySaveStatus = "No daily snapshot saved yet";
#define BT_HISTORY_FILE "/casiosync-bt-status.bin"
#define BT_HISTORY_TEMP_FILE "/casiosync-bt-status.tmp"
// User choices survive reboot; actual feature results remain RAM-only.
CasioWatchFeatures::Desired btFeatureDesired[BT_WATCH_PROFILE_COUNT];
char btFeatureBoundAddress[BT_WATCH_PROFILE_COUNT][18] = {};
uint8_t btFeatureBoundProtocol[BT_WATCH_PROFILE_COUNT] = {};
const char *btFeatureStatus[BT_WATCH_PROFILE_COUNT] = {
  "Off: time synchronization only", "Off: time synchronization only",
  "Off: time synchronization only", "Off: time synchronization only"
};
#define WATCH_OPTIONS_FILE "/casiosync-watch-options.bin"
#define WATCH_OPTIONS_TEMP_FILE "/casiosync-watch-options.tmp"
static void loadWatchOptions(void);
static bool saveWatchOptions(void);
static void applyBluetoothWatchFeatures(void);

NimBLEScan *btScan = nullptr;
NimBLEClient *btClient = nullptr;
NimBLERemoteService *btService = nullptr;
NimBLERemoteCharacteristic *btSpRequest = nullptr;
NimBLERemoteCharacteristic *btSpData = nullptr;
NimBLERemoteCharacteristic *btSetChar = nullptr;

// Scan callbacks run on the NimBLE host task. Never mutate shared Arduino
// String objects there: publish a fixed-size discovery snapshot and let loop() consume it.
volatile bool btDiscoveryReady = false;
char btDiscoveredName[48] = {};
char btDiscoveredAddress[18] = {};
char btExpectedProfileAddress[18] = {};
uint8_t btDiscoveredAddressType = 0xFF;
portMUX_TYPE btDiscoveryMux = portMUX_INITIALIZER_UNLOCKED;
uint32_t btDiscoveryGeneration = 0;
uint8_t btDiscoveryProtocol = BT_PROTOCOL_BX5600_MIP;

volatile bool btResponseActive = false;
volatile uint8_t btExpectedHeader = 0;
volatile size_t btResponseLength = 0;
#define BT_RESPONSE_CAPACITY 512
uint8_t btResponseBuffer[BT_RESPONSE_CAPACITY];
volatile unsigned long btLastFragmentMillis = 0;
volatile bool btResponseOverflow = false;
portMUX_TYPE btResponseMux = portMUX_INITIALIZER_UNLOCKED;

void initBluetoothSync(void);
void serviceBluetoothSync(void);
bool performGShockBX5600Sync(void);
bool performCasioStandardTimeSync(int protocol);
static bool btWatchNameMatches(int protocol, const String &name);
void resetBluetoothDayIfNeeded(void);
void startBluetoothWindow(int slot, bool persistent = false);
void stopBluetoothWindow(void);
static void recoverBluetoothControllerShutdown(void);
static void disconnectGShock(void);
static bool btClientQuiescent(void);
static void releaseBtClientBarrier(void);
static bool bleOperationCancelled() { return btShutdownRequested.load(std::memory_order_acquire); }
static const char *btPhase = "Idle"; // loopTask owns UI state; callbacks only publish flags.
static void setBluetoothPhase(const char *phase) { btPhase = phase; }
static bool bluetoothSettingsMutable(void);
static bool bluetoothControllerNeeded(void);
static bool shutdownIdleBluetooth(void);
static void loadBluetoothHistory(void);
static bool saveBluetoothHistoryNow(time_t epoch);


// Saved blue GPIO2 LED preference. A dedicated low-priority task owns the
// output at runtime, including while loop() blocks on a Bluetooth GATT write.
// Default on also applies to configurations from versions before V4.6.
std::atomic<bool> activityLedEnabled{true};
TaskHandle_t activityLedTaskHandle = nullptr;

//...................................................................
// WiFi Access Point Mode Configuration

bool ap_mode = false;              // WiFi mode flag: true = AP mode, false = STA mode
bool wifiConnectionAccessGrace = true; // Explicit setup/recovery grants five-minute access.
bool wifiCredentialsReconnectPending = false; // Apply after the HTTP response has returned.
bool wifiConnectionPending = false; // An explicit credential attempt may keep AP+STA active.
bool wifiRecoveryWindowActive = false;
unsigned long wifiRecoveryStarted = 0;
unsigned long last_wifi_check = 0; // Timestamp of last WiFi connection check

//...................................................................
// WiFi power management ("Always on" vs "Scheduled/power-save")
//
// Scheduled mode keeps WiFi off outside startup/recovery access, the optional
// daily web-access window and existing short NTP/lead-time wakes. These access
// daily Bluetooth preparation wakes. All exceptions use RAM-only window state.
#define WIFI_POWER_ALWAYS_ON  0
#define WIFI_POWER_SCHEDULED  1
int wifiPowerMode = WIFI_POWER_ALWAYS_ON;   // persisted config value
bool wifiAccessEnabled = false;
bool crashDumpEnabled = false; // Only user-enabled panics may write a crash dump.
int wifiAccessStart = 1080; // 18:00, disabled until explicitly enabled.
int wifiAccessEnd = 1200;   // 20:00
String wifiAccessTimezone = "Australia/Brisbane";

#define WIFI_BOOT_ON_DURATION_MS      (5UL * 60UL * 1000UL)   // 5 minutes

bool wifiRadioEnabled = true;       // Desired state; WiFi.getMode() is the observed state.
bool wifiPowerFault = false;        // RAM only: desired Off could not be reached.
uint32_t wifiPowerFaultCount = 0;
bool wifiPowerShutdownPending = false;
uint64_t wifiPowerRetryAtMs = 0;
uint32_t wifiPowerRetryDelayMs = 1000;
static const uint32_t WIFI_POWER_RETRY_MAX_MS = 60000;
unsigned long bootMillis = 0;       // Set once in setup(); anchors the post-boot on-window
bool wifiBootAccessComplete = false; // Latch prevents re-opening at each millis() rollover.
uint64_t wifiStaRetryAtMs = 0;
uint32_t wifiStaRetryDelayMs = 30000;
bool wifiClockWakeActive = false;
uint64_t wifiClockWakeStartedMs = 0;
uint64_t wifiClockRetryAtMs = 0;
uint32_t wifiClockRetryDelayMs = 30000;
uint32_t wifiClockWakeSyncCount = 0;
uint64_t wifiNtpConfigureRetryAtMs = 0;
uint32_t wifiNtpConfigureRetryDelayMs = 5000;
static const uint32_t WIFI_RETRY_MAX_MS = 15UL * 60UL * 1000UL;
static const uint32_t WIFI_CLOCK_WAKE_TIMEOUT_MS = 120000;
static const uint32_t WIFI_CLOCK_WAKE_LEAD_SEC = 60;
bool apStartPending = false;        // Configuration requested, but AP startup failed.
unsigned long apStartAttemptMillis = 0;
#define AP_START_RETRY_MS 5000UL

//...................................................................
// Debounced config persistence (flash-wear mitigation). Declared here,
// before loop(), because loop() reads these directly - unlike functions,
// plain variables/#defines are not auto-forward-declared by the Arduino
// build system, so they must appear in the file before first use. See the
// full explanation next to writeConfigNow()/saveConfig().
#define CONFIG_SAVE_DEBOUNCE_MS  3000
bool configDirty = false;
unsigned long configDirtyBecause = 0;
bool filesystemAvailable = false;
bool configStorageFault = false; // RAM only; a successful explicit save clears it.
// Web/config/schedule mutations run on loopTask, never concurrently. Share a
// fixed serialization buffer to avoid both heap fragmentation and large stack
// frames during low-memory saves. No record is committed after overflow.
static char storageSerializationBuffer[2048];

// Unsigned elapsed arithmetic keeps the flash cadence correct through
// millis() rollover. Off clears the output at the next task poll. A Bluetooth
// transaction starts with an immediate ON phase; idle holds eligible success
// steady for 24 hours and is otherwise dark.
static void writeActivityLed(bool on) {
#if defined(ACTIVITY_LED_RGB_PIN)
  rgbLedWrite(ACTIVITY_LED_RGB_PIN, 0, 0, on ? 32 : 0);
#elif !defined(ACTIVITY_LED_UNAVAILABLE)
#if defined(ACTIVITY_LED_ACTIVE_LOW)
  digitalWrite(PIN_ONBOARD_LED, on ? LOW : HIGH);
#else
  digitalWrite(PIN_ONBOARD_LED, on ? HIGH : LOW);
#endif
#else
  (void)on;
#endif
}
static void initializeActivityLed(void) {
#if !defined(ACTIVITY_LED_RGB_PIN) && !defined(ACTIVITY_LED_UNAVAILABLE)
  pinMode(PIN_ONBOARD_LED, OUTPUT);
#endif
  writeActivityLed(false);
}

static bool activityLedLevel(uint32_t nowMs, bool enabled, bool active, bool successEligible,
                             uint32_t &phaseStartMs, bool &level, bool &wasActive)
{
  return BtSyncLed::output(nowMs, enabled, active, successEligible,
                           phaseStartMs, level, wasActive);
}

static bool activityLedSyncActive(void)
{
  // Scanning/Always Wait alone are idle. Busy covers connecting and the
  // actual acknowledged time-delivery transaction, which may block loop().
  return btBleBusy.load();
}

static bool activityLedSuccessEligible(void) {
  const bool successful = btLastOutcomeSuccessful.load(std::memory_order_acquire);
  const uint32_t epoch = btLastSyncEpoch.load(std::memory_order_acquire);
  return BtSyncLed::successEligible((int64_t)time(nullptr), epoch, successful);
}

static void activityLedTask(void *)
{
  uint32_t phaseStartMs = millis();
  bool level = false;
  bool wasActive = false;
  bool writtenLevel = false;
  for (;;) {
    const bool nextLevel = activityLedLevel(millis(), activityLedEnabled.load(),
                                           activityLedSyncActive(), activityLedSuccessEligible(),
                                           phaseStartMs, level, wasActive);
    if (nextLevel != writtenLevel) {
      writeActivityLed(nextLevel);
      writtenLevel = nextLevel;
    }
    vTaskDelay(pdMS_TO_TICKS(50));
  }
}

uint32_t activityLedStackMinimum(void) {
  return activityLedTaskHandle ? (uint32_t)uxTaskGetStackHighWaterMark(activityLedTaskHandle) : 0;
}

static void safetyMonitorTask(void *) {
  for (;;) {
    vTaskDelay(pdMS_TO_TICKS(100));
    if (!safetyMonitorReady.load(std::memory_order_acquire)) continue;
    const uint64_t nowUs = (uint64_t)esp_timer_get_time();
    portENTER_CRITICAL(&progressMux);
    const uint64_t last = applicationLoopLastUs;
    portEXIT_CRITICAL(&progressMux);
    const uint32_t available = (uint32_t)uxTaskGetStackHighWaterMark(nullptr);
    if (available < monitorStackMinimum) monitorStackMinimum = available;
    if (last && nowUs >= last && nowUs-last > LOOP_PROGRESS_DEADLINE_US &&
        applicationLoopAgeMs() > LOOP_PROGRESS_DEADLINE_US / 1000ULL)
      applicationForceSafeRestart();
  }
}

static bool startSafetyMonitor(void) {
  if (safetyMonitorTaskHandle && safetyMonitorReady.load()) return true;
  applicationProgressCheckpoint();
  BaseType_t created;
#if CONFIG_FREERTOS_UNICORE
  created = xTaskCreate(safetyMonitorTask, "safetyMonitor", 2048, nullptr, 1, &safetyMonitorTaskHandle);
#else
  created = xTaskCreatePinnedToCore(safetyMonitorTask, "safetyMonitor", 2048, nullptr, 1,
                                    &safetyMonitorTaskHandle, 0);
#endif
  if (created != pdPASS || !safetyMonitorTaskHandle) {
    safetyMonitorTaskHandle = nullptr;
    Serial.println("ERROR: progress monitor unavailable; Bluetooth startup disabled");
    return false;
  }
  safetyMonitorReady.store(true, std::memory_order_release);
  return true;
}

// extern


//...................................................................
void setup(void) {
  Serial.begin(115200);
  delay(100);
  Serial.printf("started... (CasioSync firmware %s build %s)\n", FIRMWARE_VERSION, FIRMWARE_BUILD);
  Serial.printf("Reset reason: %d (4=panic, 5/6/7=watchdog, 9=brownout)\n", (int)esp_reset_reason());
  bootMillis = millis();
  WiFi.persistent(false); // Credentials are saved only in our checked config.
  initializeActivityLed();
  initFilesystem();
  loadConfig();
  applyTimezone();
  normalizeBluetoothSlots();
  if (startSafetyMonitor()) initBluetoothSync();
  else Serial.println("Bluetooth startup skipped: progress monitor unavailable");
  BaseType_t ledCreated;
#if CONFIG_FREERTOS_UNICORE
  ledCreated = xTaskCreate(activityLedTask, "activityLed", 2048, nullptr, 1, &activityLedTaskHandle);
#else
  ledCreated = xTaskCreatePinnedToCore(activityLedTask, "activityLed", 2048, nullptr, 1,
                                      &activityLedTaskHandle, 1);
#endif
  if (ledCreated != pdPASS || !activityLedTaskHandle) {
    activityLedTaskHandle = nullptr;
    Serial.println("Activity LED task unavailable; blue LED left off");
  }
  if (!filesystemAvailable || !strlen(ssid)) {
    Serial.println("No CasioSync WiFi config found, starting AP mode for configuration...");
    startAPMode();
  } else ntpstart();
  Serial.println("CasioSync watch scheduler started.");
}

void loop() {
  applicationProgressCheckpoint();
  if (wifiCredentialsReconnectPending) {
    wifiCredentialsReconnectPending=false;
    beginWifiCredentialConnection();
  }
  flushNtpLogs();
  const bool wifiConnectedNow = WiFi.status() == WL_CONNECTED;
  if (millis() - last_wifi_check > WIFI_CONNECT_CHECK_INTERVAL) {
    last_wifi_check = millis();
    checkWiFiConnection();
  }
  serviceAPStartup();
  updateWifiPowerManagement();
  if (safetyMonitorReady.load()) serviceBluetoothSync();
  servicePendingConfigSave();
  if (webServerStarted && (ap_mode || wifiConnectedNow)) server.handleClient();
  applicationProgressCheckpoint();
  delay(btIdlePowerSaveEnabled && !btWindowActive && !btBleBusy ? 10 : 1);
}


// Arduino-ESP32's newlib does not ship the IANA zoneinfo database, so
// setting TZ to an IANA name like "Asia/Tokyo" does NOT apply the correct
// UTC offset or DST rule - tzset() silently falls back to UTC when it can't
// parse the TZ string as a POSIX rule. To make the "Time zone" selector in
// the UI actually control both the displayed clock AND the transmitted
// time, each zone offered in the UI is mapped here to an equivalent POSIX
// TZ rule, which tzset()/localtime_r() parse natively (DST transitions
// included).
static bool validTimezoneName(const String &zoneName)
{
  return zoneName == "Australia/Brisbane" || zoneName == "Australia/Sydney" ||
         zoneName == "Asia/Tokyo" || zoneName == "Asia/Shanghai" ||
         zoneName == "Europe/London" || zoneName == "America/New_York" ||
         zoneName == "America/Los_Angeles" || zoneName == "UTC";
}

// Watch and Wi-Fi-access civil times never mutate the process-wide display TZ.
// Their supported zones use explicit UTC-offset/DST calculations.
static int btWeekday(int year, int month, int day)
{
  static const int table[] = {0, 3, 2, 5, 0, 3, 5, 1, 4, 6, 2, 4};
  if (month < 3) --year;
  return (year + year / 4 - year / 100 + year / 400 + table[month - 1] + day) % 7;
}

static int btNthSunday(int year, int month, int ordinal)
{
  const int firstWeekday = btWeekday(year, month, 1);
  return 1 + ((7 - firstWeekday) % 7) + (ordinal - 1) * 7;
}

static int btLastSunday(int year, int month)
{
  int days = 31;
  if (month == 4 || month == 6 || month == 9 || month == 11) days = 30;
  else if (month == 2) {
    const bool leap = (year % 4 == 0 && year % 100 != 0) || (year % 400 == 0);
    days = leap ? 29 : 28;
  }
  return days - ((btWeekday(year, month, days)) % 7);
}

static int btDayOfYear(int year, int month, int day)
{
  static const int beforeMonth[] = {0, 31, 59, 90, 120, 151, 181, 212, 243, 273, 304, 334};
  const bool leap = (year % 4 == 0 && year % 100 != 0) || (year % 400 == 0);
  return beforeMonth[month - 1] + day - 1 + (month > 2 && leap ? 1 : 0);
}

static bool btDstAtUtc(const String &zoneName, const struct tm &utc)
{
  const int year = utc.tm_year + 1900;
  const int month = utc.tm_mon + 1;
  const int day = utc.tm_mday;
  const int hour = utc.tm_hour;
  if (zoneName == "Australia/Sydney") {
    // 02:00 AEST / 03:00 AEDT on Sunday are both 16:00 UTC on
    // Saturday. Day-of-year arithmetic also handles a Sunday on the
    // first of April/October, whose UTC transition is in March/September.
    const int startDay = btDayOfYear(year, 10, btNthSunday(year, 10, 1)) - 1;
    const int endDay = btDayOfYear(year, 4, btNthSunday(year, 4, 1)) - 1;
    const int utcSeconds = ((btDayOfYear(year, month, day) * 24 + hour) * 60 + utc.tm_min) * 60 + utc.tm_sec;
    return utcSeconds >= startDay * 86400 + 16 * 3600 ||
           utcSeconds < endDay * 86400 + 16 * 3600;
  }
  if (zoneName == "Europe/London") {
    const int start = btLastSunday(year, 3);
    const int end = btLastSunday(year, 10);
    if (month > 3 && month < 10) return true;
    if (month == 3) return day > start || (day == start && hour >= 1);
    if (month == 10) return day < end || (day == end && hour < 1);
    return false;
  }
  if (zoneName == "America/New_York" || zoneName == "America/Los_Angeles") {
    const int start = btNthSunday(year, 3, 2);
    const int end = btNthSunday(year, 11, 1);
    const int startHour = zoneName == "America/New_York" ? 7 : 10;
    const int endHour = zoneName == "America/New_York" ? 6 : 9;
    if (month > 3 && month < 11) return true;
    if (month == 3) return day > start || (day == start && hour >= startHour);
    if (month == 11) return day < end || (day == end && hour < endHour);
  }
  return false;
}

static int btBaseOffsetSeconds(const String &zoneName)
{
  if (zoneName == "Australia/Brisbane" || zoneName == "Australia/Sydney") return 10 * 3600;
  if (zoneName == "Asia/Tokyo") return 9 * 3600;
  if (zoneName == "Asia/Shanghai") return 8 * 3600;
  if (zoneName == "America/New_York") return -5 * 3600;
  if (zoneName == "America/Los_Angeles") return -8 * 3600;
  return 0; // UTC and Europe/London standard time
}

static void bluetoothLocalTime(time_t utc, struct tm &out)
{
  struct tm utcTm;
  gmtime_r(&utc, &utcTm);
  const bool dst = btDstAtUtc(btTimezoneName, utcTm);
  int offset = btBaseOffsetSeconds(btTimezoneName) + (dst ? 3600 : 0) + btTimeOffsetMinutes * 60;
  time_t adjusted = utc + offset;
  gmtime_r(&adjusted, &out);
  out.tm_isdst = dst ? 1 : 0;
}

static String posixTzFor(const String &zoneName)
{
  if (zoneName == "Australia/Brisbane")  return "AEST-10";                                  // no DST
  if (zoneName == "Australia/Sydney")    return "AEST-10AEDT,M10.1.0/2,M4.1.0/3";
  if (zoneName == "Asia/Tokyo")          return "JST-9";                                    // no DST
  if (zoneName == "Asia/Shanghai")       return "CST-8";                                    // no DST
  if (zoneName == "Europe/London")       return "GMT0BST,M3.5.0/1,M10.5.0/2";
  if (zoneName == "America/New_York")    return "EST5EDT,M3.2.0/2,M11.1.0/2";
  if (zoneName == "America/Los_Angeles") return "PST8PDT,M3.2.0/2,M11.1.0/2";
  if (zoneName == "UTC")                 return "UTC0";
  return "UTC0";  // unknown zone: fall back safely rather than using a wrong display offset
}

// Applies the independent display clock timezone; BT uses its own conversion.
static void applyTimezone(void)
{
  setenv("TZ", posixTzFor(timezone_name).c_str(), 1);
  tzset();
}

// SNTP library callback, fired automatically every time a sync completes
// (see sntp_set_time_sync_notification_cb() in ntpstart()). Compares how
// far the wall clock had drifted from what it "should" say (based on the
// board's own monotonic timer) since the previous sync, and folds that
// into a smoothed drift estimate. Only clock bookkeeping and inexpensive
// interval arithmetic run here. The SDK calls this notification BEFORE
// scheduling its next request, so setting the interval here changes that
// timeout without restarting SNTP or requesting another immediate reply.
void configureAdaptiveNtp(void);
static bool ntpReplyPlausible(const struct timeval *tv)
{
  if (!tv || tv->tv_usec < 0 || tv->tv_usec >= 1000000 ||
      tv->tv_sec < 1577836800LL || tv->tv_sec >= 4102444800LL) return false;
  const uint64_t mono = (uint64_t)esp_timer_get_time();
  portENTER_CRITICAL(&clockMux);
  const bool known=clockNtpEverSynced;
  const uint64_t anchorMono=ntpLastMonoUs;
  const int64_t anchorEpoch=ntpLastEpochUs;
  portEXIT_CRITICAL(&clockMux);
  if (!known) return true;
  if (mono < anchorMono) return false;
  const uint64_t elapsed=mono-anchorMono;
  const int64_t epochUs=(int64_t)tv->tv_sec*1000000LL+tv->tv_usec;
  const int64_t expected=anchorEpoch+(int64_t)elapsed;
  const double allowedUs=2000000.0 + (double)elapsed*CLOCK_MAX_PLAUSIBLE_PPM/1000000.0;
  return fabs((double)(epochUs-expected)) <= allowedUs;
}

static void rejectNtpReply(bool countRejection)
{
  portENTER_CRITICAL(&clockMux);
  clockNtpRejected=true;
  if (countRejection && clockNtpRejectedCount != UINT32_MAX) ++clockNtpRejectedCount;
  portEXIT_CRITICAL(&clockMux);
  ntpsync=0;
  ntpIntervalSec=NTP_MIN_INTERVAL_SEC;
  sntp_set_sync_interval(NTP_MIN_INTERVAL_SEC*1000UL);
}

static bool admitNtpReply(const struct timeval *tv, bool &reacquired)
{
  reacquired = false;
  const bool valid = tv && tv->tv_usec >= 0 && tv->tv_usec < 1000000 &&
      tv->tv_sec >= 1577836800LL && tv->tv_sec < 4102444800LL;
  const uint64_t mono = (uint64_t)esp_timer_get_time();
  portENTER_CRITICAL(&clockMux);
  const bool known = clockNtpEverSynced;
  const bool rejected = clockNtpRejected;
  portEXIT_CRITICAL(&clockMux);
  if (known && !rejected && ntpReplyPlausible(tv)) return true;
  // Reacquire after ANY rejected correction, even if the next reply matches
  // the old anchor. Otherwise one stray reply could promote a bad anchor.
  // Candidate state is used only by the serialized lwIP SNTP callback.
  if (!valid) {
    ntpCandidateReplies = 0;
    portENTER_CRITICAL(&clockMux);
    clockNtpCandidateReplyCount = 0;
    portEXIT_CRITICAL(&clockMux);
    rejectNtpReply(true);
    return false;
  }
  const int64_t epochUs = (int64_t)tv->tv_sec * 1000000LL + tv->tv_usec;
  bool consistent = ntpCandidateReplies && mono >= ntpCandidateMonoUs &&
      mono >= ntpCandidateLastMonoUs &&
      mono - ntpCandidateMonoUs <= NTP_CANDIDATE_MAX_SPAN_US;
  if (consistent) {
    const uint64_t elapsed = mono - ntpCandidateMonoUs;
    const int64_t expected = ntpCandidateEpochUs + (int64_t)elapsed;
    const double allowance = 2.0 * CLOCK_INITIAL_UNCERTAINTY_SEC * 1000000.0 +
        (double)elapsed * CLOCK_MAX_PLAUSIBLE_PPM / 1000000.0;
    consistent = fabs((double)(epochUs - expected)) <= allowance;
  }
  if (!consistent) {
    ntpCandidateMonoUs = ntpCandidateLastMonoUs = mono;
    ntpCandidateEpochUs = epochUs;
    ntpCandidateReplies = 1;
  } else if (mono - ntpCandidateLastMonoUs >= NTP_CANDIDATE_MIN_STEP_US) {
    ntpCandidateLastMonoUs = mono;
    if (ntpCandidateReplies < 3) ++ntpCandidateReplies;
  }
  portENTER_CRITICAL(&clockMux);
  clockNtpCandidateReplyCount = ntpCandidateReplies;
  portEXIT_CRITICAL(&clockMux);
  if (ntpCandidateReplies >= 3 &&
      mono - ntpCandidateMonoUs >= NTP_CANDIDATE_MIN_SPAN_US) {
    // Keep the rejection latch set until wall-clock commit and bookkeeping
    // finish. BT cannot sample the new time while it is being established.
    reacquired = true;
    return true;
  }
  // Provisional consistent replies are acquisition progress, not a server
  // error. Count the initial rejected old-anchor correction separately.
  rejectNtpReply(known && !rejected);
  return false;
}

static void recordAcceptedNtpReply(struct timeval *tv, bool reacquired)
{
  const uint64_t mono = (uint64_t)esp_timer_get_time();
  const int64_t epochUs = (int64_t)tv->tv_sec * 1000000LL + tv->tv_usec;
  portENTER_CRITICAL(&clockMux);
  const uint64_t previousMono = ntpDriftAnchorMonoUs;
  const int64_t previousEpoch = ntpDriftAnchorEpochUs;
  const bool previouslySynced = clockNtpEverSynced;
  if (reacquired) {
    // A civil-time correction is not oscillator drift. Begin a fresh
    // measurement window and retain the conservative initial envelope.
    ntpDriftPpm = ntpDriftAbsSecPerHour = 0.0;
    clockDriftSampleAvailable = false;
    clockDriftBoundPpm = CLOCK_INITIAL_PPM;
    if (previouslySynced && clockNtpReacquisitionCount != UINT32_MAX)
      ++clockNtpReacquisitionCount;
  }
  portEXIT_CRITICAL(&clockMux);
  const uint64_t elapsed = mono >= previousMono ? mono - previousMono : 0;
  const int64_t expected = previousEpoch + (int64_t)elapsed;
  const int64_t correction = epochUs - expected;
  const bool measurement = previouslySynced && !reacquired && previousMono &&
      elapsed >= 300000000ULL;
  if (measurement) {
    const double ppm = (double)correction * 1000000.0 / (double)elapsed;
    // Bound measurement uncertainty at both ends. Retain recent absolute
    // peaks with slow decay; signed diagnostic EMA cannot hide reversal.
    const double measurementBound = fabs(ppm) +
         2.0 * CLOCK_INITIAL_UNCERTAINTY_SEC * 1000000000000.0 / (double)elapsed;
    portENTER_CRITICAL(&clockMux);
    ntpDriftPpm = clockDriftSampleAvailable
      ? ntpDriftPpm * (1.0 - NTP_DRIFT_EMA_ALPHA) + ppm * NTP_DRIFT_EMA_ALPHA : ppm;
    clockDriftBoundPpm = fmax(CLOCK_DRIFT_FLOOR_PPM,
        fmax(measurementBound, clockDriftBoundPpm * 0.95));
    ntpDriftAbsSecPerHour = clockDriftBoundPpm * 3600.0 / 1000000.0;
    clockDriftSampleAvailable = true;
    portEXIT_CRITICAL(&clockMux);
  }
  portENTER_CRITICAL(&clockMux);
  // Short accepted intervals accumulate against this independent anchor.
  // Resetting it after every 210-second reply would freeze uncertainty.
  if (!previouslySynced || reacquired || measurement || !previousMono) {
    ntpDriftAnchorMonoUs = mono;
    ntpDriftAnchorEpochUs = epochUs;
  }
  ntpLastMonoUs = mono;
  ntpLastEpochUs = epochUs;
  clockNtpEverSynced = true;
  clockNtpRejected = false;
  clockNtpCandidateReplyCount = 0;
  ++clockNtpSyncCount;
  portEXIT_CRITICAL(&clockMux);
  ntpCandidateReplies = 0;
  ntpsync = 1;
  configureAdaptiveNtp();
}

void onNtpSync(struct timeval *tv)
{
  // Defensive notification entry for a direct SDK callback. The strong
  // pre-commit hook below records acceptance directly, so admission runs
  // exactly once per actual received reply.
  bool reacquired = false;
  if (admitNtpReply(tv, reacquired)) recordAcceptedNtpReply(tv, reacquired);
}

// esp_sntp.h explicitly permits replacing this weak SDK function. Gate
// BEFORE settimeofday: Bluetooth cannot briefly sample a rejected time.
// This project uses immediate sync only; accepted replies preserve that mode
// and the SDK completion status, followed by our registered bookkeeping.
extern "C" void sntp_sync_time(struct timeval *tv)
{
  bool reacquired = false;
  if (!admitNtpReply(tv, reacquired)) {
    sntp_set_sync_status(SNTP_SYNC_STATUS_RESET);
    return;
  }
  const int commitResult = settimeofday(tv, nullptr);
  if (commitResult != 0) {
    rejectNtpReply(true);
    sntp_set_sync_status(SNTP_SYNC_STATUS_RESET);
    return;
  }
  sntp_set_sync_status(SNTP_SYNC_STATUS_COMPLETED);
  recordAcceptedNtpReply(tv, reacquired);
}

// Recalculates ntpIntervalSec from the current drift estimate and applies
// it from the notification callback before the next SNTP timer is armed.
// Reserve initial sync uncertainty and leave a margin before the same
// error/six-hour limits used by clockConfidence(). Unknown drift keeps
// the initial one-hour interval and the conservative 50 ppm error bound.
void configureAdaptiveNtp(void)
{
  portENTER_CRITICAL(&clockMux);
  bool measured=clockDriftSampleAvailable;
  double samplePpm=clockDriftBoundPpm;
  portEXIT_CRITICAL(&clockMux);
  uint32_t interval = NTP_INITIAL_INTERVAL_SEC;
  if (measured) {
    double seconds = CLOCK_MAX_HOLDOVER_SEC * NTP_RESYNC_MARGIN;
    const double drift = fabs(samplePpm) / 1000000.0;
    if (drift > 0.0) {
      const double errorSeconds = (NTP_ERROR_BUDGET_SEC - CLOCK_INITIAL_UNCERTAINTY_SEC) * NTP_RESYNC_MARGIN / drift;
      if (seconds > errorSeconds) seconds = errorSeconds;
    }
    if (seconds < NTP_MIN_INTERVAL_SEC) seconds = NTP_MIN_INTERVAL_SEC;
    interval = (uint32_t)seconds;
  }
  ntpIntervalSec = interval;
  sntp_set_sync_interval(interval * 1000UL);
}

static void flushNtpLogs(void)
{
  static uint32_t lastLoggedSyncCount = 0;
  portENTER_CRITICAL(&clockMux);
  const uint32_t completed = clockNtpSyncCount;
  portEXIT_CRITICAL(&clockMux);
  if (completed != lastLoggedSyncCount) {
    lastLoggedSyncCount = completed;
    Serial.println("NTP synchronized (confirmed server reply)");
  }
}

static bool configureNtpClient(void) {
  if (WiFi.status() != WL_CONNECTED) return false;
  sntp_set_time_sync_notification_cb(onNtpSync);
  sntp_set_sync_mode(SNTP_SYNC_MODE_IMMED);
  const String tzRule = posixTzFor(timezone_name);
  if (!tzRule.length()) {
    Serial.println("ERROR: NTP timezone allocation failed; retaining previous clock");
    return false;
  }
  sntp_set_sync_interval(ntpIntervalSec.load() * 1000UL);
  ntpsync = 0;
  configTzTime(tzRule.c_str(), "pool.ntp.org", "time.nist.gov");
  Serial.println("NTP client started; awaiting a confirmed server reply");
  return esp_sntp_enabled();
}

void ntpstart(void)
{
  // Start association once. checkWiFiConnection() handles completion,
  // deadlines and SNTP startup without blocking loopTask with delay loops.
  if (wifiConnectionPending) return;
  wifiPowerShutdownPending = false;
  wifiPowerRetryAtMs = 0;
  wifiPowerRetryDelayMs = 1000;
  if (!filesystemAvailable || strlen(ssid) == 0) { startAPMode(); return; }
  Serial.printf("Attempting to connect to Network named: %s\n", ssid);
  const bool recoveringFromAP = ap_mode;
  beginWifiCredentialConnection();
  if (wifiConnectionPending && !recoveringFromAP) wifiConnectionAccessGrace = false;
}

// Cleanly shuts down networking: stops the SNTP client, disconnects WiFi,
// and powers the radio off entirely (WIFI_OFF, not just disconnected - this
// actually powers down the WiFi hardware for real power savings). Used by
// updateWifiPowerManagement() to end a scheduled sync window in Power-save
// mode.
bool ntpstop(void)
{
  // Wi-Fi sleep does not invalidate a previously synchronized holdover clock.
  // Stopping an unstarted client can post to an uninitialized TCP/IP mailbox.
  const uint64_t nowMs = (uint64_t)esp_timer_get_time() / 1000ULL;
  if (wifiPowerShutdownPending && nowMs < wifiPowerRetryAtMs) return false;
  if (esp_sntp_enabled()) esp_sntp_stop();
  if (webServerStarted) { server.stop(); webServerStarted=false; }
  const bool disconnected = WiFi.disconnect(true);
  const bool disabled = WiFi.mode(WIFI_OFF);
  const bool observedOff = WiFi.getMode() == WIFI_OFF && WiFi.status() != WL_CONNECTED;
  if (!disconnected || !disabled || !observedOff) {
    if (wifiPowerFaultCount != UINT32_MAX) ++wifiPowerFaultCount;
    Serial.println("ERROR: WiFi shutdown was not fully acknowledged; checking observed mode");
  }
  if (observedOff) {
    wifiPowerFault = wifiPowerShutdownPending = false;
    wifiPowerRetryAtMs = 0;
    wifiPowerRetryDelayMs = 1000;
    return true;
  }
  wifiPowerFault = wifiPowerShutdownPending = true;
  wifiPowerRetryAtMs = nowMs + wifiPowerRetryDelayMs;
  wifiPowerRetryDelayMs = wifiPowerRetryDelayMs < WIFI_POWER_RETRY_MAX_MS / 2
      ? wifiPowerRetryDelayMs * 2 : WIFI_POWER_RETRY_MAX_MS;
  // A failed Off must not strand a still-connected station with no web
  // server or clock service. Preserve access while bounded retries run.
  if (WiFi.status() == WL_CONNECTED) {
    if (!webServerStarted) initWebServer();
    if (!esp_sntp_enabled()) (void)configureNtpClient();
  }
  return false;
}


//...................................................................
// New functions for web UI and configuration

// Flash-wear mitigation #2: uses LittleFS rather than SPIFFS. SPIFFS is
// deprecated by Espressif for exactly the reasons relevant here - it has
// weaker wear-leveling than LittleFS, and a write interrupted by power loss
// (e.g. someone unplugs the board mid-save) can corrupt the whole file
// rather than just losing the in-progress write. LittleFS is a drop-in
// replacement in modern Arduino-ESP32 with the same File/open()/read API
// used below, so no other code needed to change.

//...................................................................
// GW-BX5600 BLE protocol implementation

static bool btWatchNameMatches(int protocol, const String &advertisedName) {
  if (!validBtProtocol(protocol)) return false;
  return CasioModelCatalog::matches(static_cast<CasioModelCatalog::Protocol>(protocol),
                                    advertisedName.c_str(),advertisedName.length());
}

class GShockScanCallbacks : public NimBLEScanCallbacks {
public:
  void onResult(const NimBLEAdvertisedDevice *advertisedDevice) override {
    if (!advertisedDevice || !btWindowActive || btBleBusy) return;
    if (!advertisedDevice->haveServiceUUID() ||
        !advertisedDevice->isAdvertisingService(NimBLEUUID(CASIO_ADVERTISEMENT_SERVICE))) return;

    const bool hasName=advertisedDevice->haveName();
    const std::string name=hasName?advertisedDevice->getName():std::string();
    portENTER_CRITICAL(&btDiscoveryMux);
    uint8_t protocol = btDiscoveryProtocol;
    uint32_t generation = btDiscoveryGeneration;
    portEXIT_CRITICAL(&btDiscoveryMux);
    const bool nameMatches=CasioModelCatalog::matches(static_cast<CasioModelCatalog::Protocol>(protocol),name.data(),name.size());
    const bool unnamedBx=protocol==BT_PROTOCOL_BX5600_MIP && !hasName;
    if (!nameMatches && !unnamedBx) return;
    const std::string address=advertisedDevice->getAddress().toString();

    portENTER_CRITICAL(&btDiscoveryMux);
    bool expectedMatches = !btExpectedProfileAddress[0] ||
                           strcasecmp(btExpectedProfileAddress, address.c_str()) == 0;
    const bool identified = nameMatches || (unnamedBx && btExpectedProfileAddress[0] && expectedMatches);
    if (generation == btDiscoveryGeneration && btWindowActive && expectedMatches && identified && !btDiscoveryReady) {
      strlcpy(btDiscoveredName, name.c_str(), sizeof(btDiscoveredName));
      strlcpy(btDiscoveredAddress, address.c_str(), sizeof(btDiscoveredAddress));
      btDiscoveredAddressType = advertisedDevice->getAddressType();
      btDiscoveryReady = true;
    }
    portEXIT_CRITICAL(&btDiscoveryMux);
  }
};

// NimBLE calls onDisconnect before its GAP handler clears the connection
// handle and releases any blocked GATT procedure. Publish the reuse barrier
// from a subsequent host event, rather than from inside that callback.
static std::atomic<bool> btClientConnected{false};
static std::atomic<bool> btClientConnectionPending{false};
static std::atomic<bool> btClientQuiescentReady{true};
static ble_npl_event btClientTeardownBarrierEvent{};
static ble_npl_callout btClientPreemptionCallout{};
static bool btClientBarrierEventInitialized = false;
static bool btClientPreemptionInitialized = false;
static std::atomic<bool> btClientPreemptionEnabled{false};
static std::atomic<bool> btClientTerminationRequested{false};
static std::atomic<uint32_t> btHostStackMinimumBytes{UINT32_MAX};

uint32_t bluetoothHostStackMinimum(void) {
  const uint32_t sample = btHostStackMinimumBytes.load(std::memory_order_acquire);
  return sample == UINT32_MAX ? 0 : sample;
}

static void sampleBluetoothHostStack(void) {
  // ESP-IDF reports stack high-water marks in bytes, unlike generic FreeRTOS.
  const uint32_t sample = uxTaskGetStackHighWaterMark(nullptr);
  uint32_t previous = btHostStackMinimumBytes.load(std::memory_order_relaxed);
  while (sample < previous && !btHostStackMinimumBytes.compare_exchange_weak(previous, sample,
           std::memory_order_release, std::memory_order_relaxed)) {}
}
static std::atomic<bool> btTransactionActive{false};
static std::atomic<uint32_t> btTransactionStartedMillis{0};
static constexpr uint32_t BT_TRANSACTION_DEADLINE_MS = 45000;
static bool btClientQuarantineActive = false;
static uint32_t btClientQuarantineStartedMillis = 0;
static uint32_t btClientQuarantineLastRetryMillis = 0;

// Admission checks reduce pressure before SDK allocations; the two retained
// singleton allocations also use nothrow in the pinned library. The SDK's
// other STL allocations still require a reserve rather than a null check.
static bool bluetoothMemoryAvailable(bool initializing = false) {
  const uint32_t freeBytes = heap_caps_get_free_size(MALLOC_CAP_INTERNAL | MALLOC_CAP_8BIT);
  const uint32_t largest = heap_caps_get_largest_free_block(MALLOC_CAP_INTERNAL | MALLOC_CAP_8BIT);
  return freeBytes >= (initializing ? 65536U : 32768U) &&
         largest >= (initializing ? 24576U : 12288U);
}

static bool btTransactionDeadlineReached(void) {
  return btTransactionActive.load(std::memory_order_acquire) &&
         static_cast<uint32_t>(millis() - btTransactionStartedMillis.load(std::memory_order_acquire)) >=
           BT_TRANSACTION_DEADLINE_MS;
}

static uint32_t btTransactionRemainingMs(void) {
  if (!btTransactionActive.load(std::memory_order_acquire)) return 0;
  const uint32_t elapsed=millis()-btTransactionStartedMillis.load(std::memory_order_acquire);
  return elapsed<BT_TRANSACTION_DEADLINE_MS?BT_TRANSACTION_DEADLINE_MS-elapsed:0;
}
static uint32_t optionalReplyTimeoutMs(uint32_t maximum=1200) {
  const uint32_t remaining=btTransactionRemainingMs();
  constexpr uint32_t finalTimeReserve=5000;
  if (remaining<=finalTimeReserve) return 0;
  const uint32_t available=remaining-finalTimeReserve;
  return available<maximum?available:maximum;
}

static bool btTransactionCancelled(void) {
  return bleOperationCancelled() || btTransactionDeadlineReached() ||
         (btTransactionActive.load(std::memory_order_acquire) && !clockTrusted());
}

// Both loop() and the host monitor can request termination. Only one submits
// the GAP operation per connection state; no caller destroys client objects.
static bool requestBtClientTermination(void) {
  if (!btClient) return true;
  bool expected = false;
  if (!btClientTerminationRequested.compare_exchange_strong(expected, true)) return true;
  bool requested = true;
  if (btClient->getConnHandle() != BLE_HS_CONN_HANDLE_NONE)
    requested = btClient->disconnect();
  else if (btClientConnectionPending.load(std::memory_order_acquire))
    requested = btClient->cancelConnect();
  if (!requested) btClientTerminationRequested.store(false, std::memory_order_release);
  return requested;
}

static void drainBtClientPreemption(void) {
  if (!btClientPreemptionInitialized) return;
  ble_npl_callout_stop(&btClientPreemptionCallout);
#if !CONFIG_BT_LE_CONTROLLER_NPL_OS_PORTING_SUPPORT
  // The classic ESP32's NPL callout exposes its event. Stop its timer and
  // remove a previously queued expiry before teardown/cache reuse.
  ble_npl_eventq_remove(nimble_port_get_dflt_eventq(), &btClientPreemptionCallout.ev);
#endif
}

static void btClientPreemptionCheck(ble_npl_event *event) {
  (void)event;
  sampleBluetoothHostStack();
  if (!btClientPreemptionEnabled.load(std::memory_order_acquire)) return;
  if (btTransactionCancelled()) {
    // Executed on the NimBLE host, so a loopTask blocked in synchronous GATT
    // is released by the normal GAP disconnect/ATT cancellation path.
    if (!requestBtClientTermination())
      Serial.println("BT: deadline/clock-trust host disconnect failed; retrying");
  }
  if (btClientPreemptionEnabled.load(std::memory_order_acquire) &&
      ble_npl_callout_reset(&btClientPreemptionCallout, ble_npl_time_ms_to_ticks32(20)) != BLE_NPL_OK) {
    btClientPreemptionEnabled.store(false, std::memory_order_release);
    Serial.println("BT: transaction deadline monitor stopped; terminating connection safely");
    requestBtClientTermination();
  }
}

static void btClientTeardownBarrier(ble_npl_event *event) {
  (void)event;
  // This host event runs after GAP teardown; any queued monitor expiry can no
  // longer initiate a connection or touch a characteristic cache.
  drainBtClientPreemption();
  btClientQuiescentReady.store(true, std::memory_order_release);
}

static bool initializeBtClientBarrier(void) {
  if (!btClientBarrierEventInitialized) {
    ble_npl_event_init(&btClientTeardownBarrierEvent, btClientTeardownBarrier, nullptr);
    btClientBarrierEventInitialized = true;
  }
  if (!btClientPreemptionInitialized) {
    if (NIMBLE_RADIOCLOCK_CALLOUT_INIT(&btClientPreemptionCallout, nimble_port_get_dflt_eventq(),
                            btClientPreemptionCheck, nullptr) != 0) {
      Serial.println("BT: transaction deadline monitor allocation failed; connection disabled");
      return false;
    }
    btClientPreemptionInitialized = true;
  }
  return true;
}

// Call only while the host is running and after btClientQuiescent(). Events
// and timers must not retain the old host event queue across deinit/reinit.
static void releaseBtClientBarrier(void) {
  btClientPreemptionEnabled.store(false, std::memory_order_release);
  drainBtClientPreemption();
  if (btClientPreemptionInitialized) {
    ble_npl_callout_deinit(&btClientPreemptionCallout);
    btClientPreemptionInitialized = false;
    btClientPreemptionCallout = {};
  }
  if (btClientBarrierEventInitialized) {
    ble_npl_event_deinit(&btClientTeardownBarrierEvent);
    btClientBarrierEventInitialized = false;
    btClientTeardownBarrierEvent = {};
  }
}

static bool btClientQuiescent(void) {
  return !btClient ||
         (btClientQuiescentReady.load(std::memory_order_acquire) &&
          !btClientConnectionPending.load(std::memory_order_acquire) &&
          !btClientConnected.load(std::memory_order_acquire) &&
          btClient->getConnHandle() == BLE_HS_CONN_HANDLE_NONE);
}

// A late GAP/barrier completion can recover without deleting any retained
// callback storage. If teardown never completes, use controlled recovery
// rather than deleting live objects or remaining blocked indefinitely.
static bool serviceBtClientQuarantine(void) {
  if (!btBleBusy || btClientQuiescent()) {
    btClientQuarantineActive = false;
    return true;
  }
  const uint32_t now = millis();
  if (!btClientQuarantineActive) {
    btClientQuarantineActive = true;
    btClientQuarantineStartedMillis = now;
    btClientQuarantineLastRetryMillis = now;
  }
  if (static_cast<uint32_t>(now - btClientQuarantineStartedMillis) >= 60000U) {
    Serial.println("BT: teardown did not recover within 60 seconds; restarting safely");
    applicationForceSafeRestart();
    return false;
  }
  if (static_cast<uint32_t>(now - btClientQuarantineLastRetryMillis) >= 1000U) {
    btClientQuarantineLastRetryMillis = now;
    requestBtClientTermination();
  }
  return false;
}

class GShockClientCallbacks : public NimBLEClientCallbacks {
public:
  void onConnect(NimBLEClient *client) override {
    (void)client;
    sampleBluetoothHostStack();
    // A cancel-connect racing with successful establishment must be followed
    // by an actual disconnect; let the monitor/loop submit the new operation.
    btClientTerminationRequested.store(false, std::memory_order_release);
    btClientConnected.store(true, std::memory_order_release);
    btClientConnectionPending.store(false, std::memory_order_release);
    Serial.println("BT: Casio watch connected");
  }
  void onConnectFail(NimBLEClient *client, int reason) override {
    (void)client;
    sampleBluetoothHostStack();
    Serial.printf("BT: Casio connection failed (reason=%d)\n", reason);
    publishDisconnected();
  }
  void onDisconnect(NimBLEClient *client, int reason) override {
    (void)client;
    sampleBluetoothHostStack();
    Serial.printf("BT: Casio watch disconnected (reason=%d)\n", reason);
    publishDisconnected();
  }
  void onMTUChange(NimBLEClient *client, uint16_t mtu) override {
    (void)client;
    Serial.printf("BT: negotiated ATT MTU=%u\n", mtu);
  }
private:
  static void publishDisconnected(void) {
    // Never delete the client, its services or characteristics in a callback.
    btClientPreemptionEnabled.store(false, std::memory_order_release);
    if (btClientPreemptionInitialized) ble_npl_callout_stop(&btClientPreemptionCallout);
    btClientConnected.store(false, std::memory_order_release);
    btClientConnectionPending.store(false, std::memory_order_release);
    btClientQuiescentReady.store(false, std::memory_order_release);
    ble_npl_eventq_put(nimble_port_get_dflt_eventq(), &btClientTeardownBarrierEvent);
  }
};
static GShockClientCallbacks gshockClientCallbacks;

static void gshockNotifyCallback(NimBLERemoteCharacteristic *characteristic,
                                 uint8_t *data, size_t length, bool isNotify) {
  (void)isNotify;
  if (!characteristic || !data || !length) return;
  const bool fromSpData = characteristic->getUUID() == NimBLEUUID(CASIO_SP_DATA_CHAR);
  const bool fromBasicSettings = characteristic->getUUID() == NimBLEUUID(CASIO_SET_CHAR);
  if (!fromSpData && !fromBasicSettings) return;
  portENTER_CRITICAL(&btResponseMux);
  // First packet has the response header; continuation packets need not.
  // Buffer bounds are strict: never pass silently truncated watch data back.
  // Basic settings and watch condition arrive on TIME/all-features;
  // SP replies arrive on SP_DATA.
  // Reject unrelated time notifications and interleaved responses.
  const bool correctChannel = (btExpectedHeader == CasioWatchFeatures::kBasicHeader ||
                               btExpectedHeader == CasioWatchFeatures::kFirstAlarmHeader ||
                               btExpectedHeader == CasioWatchFeatures::kOtherAlarmsHeader ||
                               btExpectedHeader == CasioWatchFeatures::kTimerHeader ||
                               btExpectedHeader == CasioWatchFeatures::kAutoAdjustHeader ||
                               btExpectedHeader == CasioWatchBattery::kHeader)
                                ? fromBasicSettings : fromSpData;
  if (btResponseActive && correctChannel && (btResponseLength != 0 || data[0] == btExpectedHeader)) {
    if (length > sizeof(btResponseBuffer) - btResponseLength) {
      btResponseOverflow = true;
      ++btResponseErrors;
      btResponseActive = false;
    } else {
      memcpy(btResponseBuffer + btResponseLength, data, length);
      btResponseLength += length;
      btLastFragmentMillis = millis();
      ++btNotifications;
    }
  }
  portEXIT_CRITICAL(&btResponseMux);
}

static void clearBtDiscovery(void) {
  portENTER_CRITICAL(&btDiscoveryMux);
  ++btDiscoveryGeneration;
  btDiscoveryReady = false;
  btDiscoveredName[0] = '\0';
  btDiscoveredAddress[0] = '\0';
  btDiscoveredAddressType = 0xFF;
  portEXIT_CRITICAL(&btDiscoveryMux);
}

static bool consumeBtDiscovery(String &name, String &address, uint8_t &addressType) {
  char nameCopy[sizeof(btDiscoveredName)];
  char addressCopy[sizeof(btDiscoveredAddress)];
  bool ready;
  portENTER_CRITICAL(&btDiscoveryMux);
  ready = btDiscoveryReady;
  if (ready) {
    memcpy(nameCopy, btDiscoveredName, sizeof(nameCopy));
    memcpy(addressCopy, btDiscoveredAddress, sizeof(addressCopy));
    addressType = btDiscoveredAddressType;
    btDiscoveryReady = false;
  }
  portEXIT_CRITICAL(&btDiscoveryMux);
  if (!ready) return false;
  nameCopy[sizeof(nameCopy)-1] = '\0';
  addressCopy[sizeof(addressCopy)-1] = '\0';
  name = nameCopy;
  address = addressCopy;
  return address.length() == 17;
}

static void cancelBtResponse(void) {
  portENTER_CRITICAL(&btResponseMux);
  btResponseActive = false;
  portEXIT_CRITICAL(&btResponseMux);
}

static unsigned long btShutdownRetryMillis = 0;
static CasioBleScanControl btScanControl;
static bool btShutdownRecoveryActive = false; // loopTask owns this common shutdown budget.
static uint32_t btShutdownRecoveryStartedMillis = 0;
static constexpr uint32_t BT_SHUTDOWN_RECOVERY_DEADLINE_MS = 60000;

// Each individual queue/deinit attempt is bounded, but successful loop returns
// do not prove host progress. Keep one deadline across scanner, client and
// controller failures, including when there is no connected client. Preserve
// every event/callback until physical controller-off is confirmed.
static bool serviceBtShutdownProgress(void) {
  const uint32_t now = millis();
  if (!btShutdownRecoveryActive) {
    btShutdownRecoveryActive = true;
    btShutdownRecoveryStartedMillis = now;
  }
  if (static_cast<uint32_t>(now - btShutdownRecoveryStartedMillis) >=
      BT_SHUTDOWN_RECOVERY_DEADLINE_MS) {
    Serial.println("BT: host/controller shutdown made no safe progress within 60 seconds; restarting safely");
    applicationForceSafeRestart();
    return false;
  }
  return true;
}

static void completeBtShutdownProgress(void) {
  btShutdownRecoveryActive = false;
  btShutdownRecoveryStartedMillis = 0;
}

static bool bluetoothScanMayStart(void) {
  return btBleInitialized && btWindowActive && !btBleBusy &&
         !bleOperationCancelled() && btControllerStarted && bluetoothMemoryAvailable();
}

// In NimBLE 2.5.1, init() may return false after enabling the controller but
// before starting the host. deinit() is then a no-op. Clean up that exact
// partial-init case using Espressif's controller API, preserving all checks.
static bool stopPartiallyInitializedBluetooth(void) {
  if (NimBLEDevice::isInitialized()) return false;
  if (esp_bt_controller_get_status() == ESP_BT_CONTROLLER_STATUS_ENABLED &&
      esp_bt_controller_disable() != ESP_OK) return false;
  if (esp_bt_controller_get_status() == ESP_BT_CONTROLLER_STATUS_INITED &&
      esp_bt_controller_deinit() != ESP_OK) return false;
  return esp_bt_controller_get_status() == ESP_BT_CONTROLLER_STATUS_IDLE;
}


void initBluetoothSync(void) {
  if (btIdlePowerSaveEnabled && !bluetoothControllerNeeded()) return;
  if (btBleInitialized || (btShutdownRetryMillis && (long)(millis()-btShutdownRetryMillis)<0) ||
      bleOperationCancelled()) return;
  if (!bluetoothMemoryAvailable(true)) {
    btLastSyncStatus = "Bluetooth deferred: insufficient internal memory";
    btShutdownRetryMillis = millis() + 1000;
    return;
  }
  if (btControllerStarted) return;
  btControllerStarted = true;
  if (!NimBLEDevice::init("CasioSync")) {
    // An unsuccessful init may still leave the controller enabled. Keep the
    // ownership gate closed unless the physical controller is verified off.
    bool off = stopPartiallyInitializedBluetooth();
    if (off) btControllerStarted = false;
    btLastSyncStatus = "Bluetooth initialization failed";
    btShutdownRequested = !off;
    btShutdownRetryMillis = millis() + 1000;
    Serial.println("ERROR: BLE initialization failed; controller shutdown must complete before reuse");
    return;
  }
  btShutdownRetryMillis = 0;
  btBleInitialized = true;
  btScan = NimBLEDevice::getScan();
  if (!btScan) {
    btLastSyncStatus = "Bluetooth scanner allocation failed";
    btShutdownRequested = true;
    Serial.println("ERROR: BLE scanner unavailable; shutting down before reuse");
    return;
  }
  static GShockScanCallbacks scanCallbacks;
  btScan->setScanCallbacks(&scanCallbacks, false);
  btScan->setActiveScan(true);
  btScan->setInterval(80);
  btScan->setWindow(60);
  btScan->setMaxResults(0);
  // One-second scan completion reports advertisers lacking a response. Avoid
  // a second timeout callout that could outlive a controller restart.
  btScan->setScanResponseTimeout(0);
  if (!btScanControl.initialize(btScan, BT_SCAN_SLICE_MS, bluetoothScanMayStart)) {
    btLastSyncStatus = "Bluetooth scan control initialization failed";
    btShutdownRequested = true;
    Serial.println("ERROR: Bluetooth scan control unavailable; shutdown pending");
    return;
  }
  Serial.println("BT: NimBLE Casio time-only service ready");
}

static void recoverBluetoothControllerShutdown(void) {
  // Capture the window once before cancelling. Failed automatic windows can
  // reopen inside the same civil-time occurrence after recovery.
  static bool captured = false;
  if (!captured) {
    captured = true;
    if (btPairModeActive) btPairRequested = true;
    else if (btSyncActiveSlot >= 0) {
      btSlotAttemptYear[btSyncActiveSlot] = -1;
      btSlotAttemptYday[btSyncActiveSlot] = -1;
    } else if (btWindowActive && !btPersistentWaitActive) btManualSyncRequested = true;
    stopBluetoothWindow();
    cancelBtResponse();
  }
  disconnectGShock();
  if (shutdownIdleBluetooth()) captured = false;
}


void resetBluetoothDayIfNeeded(void) {
  time_t epoch;
  time(&epoch);
  struct tm day;
  bluetoothLocalTime(epoch, day);
  btSyncDayComplete = false; // Informational: any watch profile delivered today.
  for (int i = 0; i < BT_WATCH_PROFILE_COUNT; ++i)
    if (btProfileDoneToday(i)) btSyncDayComplete = true;
}

static int btMinutesOfDay(const struct tm &t) {
  return t.tm_hour * 60 + t.tm_min;
}

static bool btMinuteInBluetoothWindow(int currentMinute, int slotMinute) {
  const int start = (slotMinute - BT_PREPARE_MINUTES + 1440) % 1440;
  const int elapsed = (currentMinute - start + 1440) % 1440;
  return elapsed <= BT_PREPARE_MINUTES + BT_WINDOW_AFTER_MINUTES;
}

// One occurrence belongs to the scheduled target's BT calendar day, even
// when its preparation or trailing listening minutes cross midnight.
static void btSlotOccurrenceDate(int slot, const struct tm &local, int &year, int &yday) {
  year = local.tm_year + 1900;
  yday = local.tm_yday;
  const int delta = btSyncTimes[slot] - btMinutesOfDay(local);
  auto daysInYear = [](int y) { return 365 + ((y % 4 == 0 && y % 100 != 0) || y % 400 == 0); };
  if (delta < -720) {
    if (++yday >= daysInYear(year)) { ++year; yday = 0; }
  } else if (delta > 720) {
    if (--yday < 0) { --year; yday = daysInYear(year) - 1; }
  }
}


static bool bluetoothProfileBindingReady(uint8_t profile, uint8_t protocol) {
  return profile < BT_WATCH_PROFILE_COUNT && validBtProtocol(protocol) &&
         btProfileAddress[profile].length() == 17 && btProfileProtocol[profile] == protocol;
}

void startBluetoothWindow(int slot, bool persistent) {
  if (!btBleInitialized || bleOperationCancelled() || btBleBusy || btWindowActive) return;
  if (slot >= 0) {
    btPairModeActive = false;
    if (slot >= BT_SYNC_SLOT_COUNT || !btSyncEnabled[slot]) return;
    btSyncActiveSlot = slot;
    btActiveProtocol = btSyncProtocol[slot];
    btActiveProfile = btSyncProfile[slot];
  } else {
    btSyncActiveSlot = -1;
    btActiveProtocol = btManualProtocol;
    btActiveProfile = btManualProfile;
  }
  // Only explicit pairing may accept an unbound/replacement watch, in every
  // window type (manual, automatic and Always Wait).
  if (btActiveProfile >= BT_WATCH_PROFILE_COUNT || !validBtProtocol(btActiveProtocol) ||
      (!btPairModeActive && !bluetoothProfileBindingReady(btActiveProfile, btActiveProtocol))) {
    btLastSyncStatus = "Pair Watch first for the selected profile and protocol";
    setBluetoothPhase("No watch paired");
    btSyncActiveSlot = -1;
    return;
  }
  btPersistentWaitActive = persistent;
  btLastWatchAddress = "";
  btLastWatchAddressType = 0xFF;
  clearBtDiscovery();
  portENTER_CRITICAL(&btDiscoveryMux);
  btDiscoveryProtocol = btActiveProtocol;
  if (!btPairModeActive)
    strlcpy(btExpectedProfileAddress, btProfileAddress[btActiveProfile].c_str(), sizeof(btExpectedProfileAddress));
  else btExpectedProfileAddress[0] = '\0';
  btWindowActive = true;
  portEXIT_CRITICAL(&btDiscoveryMux);
  unsigned long remainingSeconds = (unsigned long)BT_MANUAL_WINDOW_MINUTES * 60UL;
  if (slot>=0) {
    time_t epoch=time(nullptr); struct tm local; bluetoothLocalTime(epoch,local);
    const int start=(btSyncTimes[slot]-BT_PREPARE_MINUTES+1440)%1440;
    const int finish=(btSyncTimes[slot]+BT_WINDOW_AFTER_MINUTES)%1440;
    const int elapsedMinutes=(btMinutesOfDay(local)-start+1440)%1440;
    const int windowSeconds=(BT_PREPARE_MINUTES+BT_WINDOW_AFTER_MINUTES+1)*60;
    const int elapsedSeconds=elapsedMinutes*60+local.tm_sec;
    if (elapsedSeconds >= windowSeconds) { stopBluetoothWindow(); return; }
    remainingSeconds=(unsigned long)(windowSeconds-elapsedSeconds);
    // Count only an opened window with a valid watch binding. A rejected
    // opening must remain eligible if pairing completes during this window.
    btSlotOccurrenceDate(slot, local, btSlotAttemptYear[slot], btSlotAttemptYday[slot]);
    Serial.printf("BT SCHED: Watch %u target %02d:%02d %s; listen window %02d:%02d-%02d:%02d; entered at %02d:%02d:%02d\n",
                  btActiveProfile+1, btSyncTimes[slot]/60, btSyncTimes[slot]%60,
                  btTimezoneName.c_str(), start/60, start%60, finish/60, finish%60,
                  local.tm_hour, local.tm_min, local.tm_sec);
  }
  btWindowEndMillis = millis()+remainingSeconds*1000UL;
  if (!persistent && WiFi.status() == WL_CONNECTED) sntp_restart();
  setBluetoothPhase(btPairModeActive ? "Pairing" :
                    slot >= 0 ? "Automatic sync window active" : "Waiting for watch");
  Serial.printf("BT: %s for Watch %u using %s protocol\n",
                persistent ? "Always Wait listening" : btPhase,
                btActiveProfile+1, btProtocolName(btActiveProtocol));
}

void stopBluetoothWindow(void) {
  btWindowActive = false;
  if (btBleInitialized && !btScanControl.stop()) {
    btShutdownRequested = true;
    serviceBtShutdownProgress();
    Serial.println("BT: scan stop not acknowledged; retaining host/controller ownership");
  }
  clearBtDiscovery();
  btSyncActiveSlot = -1;
  btPairModeActive = false;
  btPersistentWaitActive = false;
  setBluetoothPhase("Idle");
}

// Changing one automatic slot must make that slot eligible again without
// interrupting a manual request, passive listening, or another slot. The next
// service pass opens it only inside its BT-time window and after the scanner is ready.
static void resetBluetoothSlotAttempt(int slot) {
  btSlotAttemptYear[slot] = -1;
  btSlotAttemptYday[slot] = -1;
  if (btSyncActiveSlot == slot) stopBluetoothWindow();
}

// Arm notification reception BEFORE sending the BLE request; otherwise a fast
// response can arrive while writeValue() is still returning and be discarded.
static void prepareBtResponse(uint8_t header) {
  portENTER_CRITICAL(&btResponseMux);
  btResponseActive = false;
  btExpectedHeader = header;
  btResponseLength = 0;
  btResponseOverflow = false;
  btLastFragmentMillis = millis();
  btResponseActive = true;
  portEXIT_CRITICAL(&btResponseMux);
}

// Dynamic response assembly: first fragment identifies the request; collect
// continuations until an idle gap, with a minimum size and hard overflow guard.
static bool waitBt(size_t minimum, uint32_t timeoutMs = BT_REQUEST_TIMEOUT_MS) {
  uint32_t started = millis();
  while (millis() - started < timeoutMs) {
    if (btTransactionCancelled() || !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
        !btClientConnected.load(std::memory_order_acquire)) {
      cancelBtResponse();
      Serial.println("BT: response wait cancelled (shutdown, deadline or watch disconnected)");
      return false;
    }
    portENTER_CRITICAL(&btResponseMux);
    size_t n = btResponseLength;
    unsigned long last = btLastFragmentMillis;
    bool overflow = btResponseOverflow;
    portEXIT_CRITICAL(&btResponseMux);
    if (overflow) { cancelBtResponse(); return false; }
    if (n >= minimum && millis() - last >= 300UL) {
      cancelBtResponse();
      return true;
    }
    delay(5);
  }
  cancelBtResponse();
  ++btResponseErrors;
  Serial.printf("BT: response timeout (expected header=0x%02x, minimum=%u bytes)\n",
                btExpectedHeader, (unsigned)minimum);
  return false;
}

static size_t copyBt(uint8_t *dst, size_t maxLen) {
  portENTER_CRITICAL(&btResponseMux);
  size_t n = btResponseLength < maxLen ? btResponseLength : maxLen;
  memcpy(dst, btResponseBuffer, n);
  portEXIT_CRITICAL(&btResponseMux);
  return n;
}

// Write mode is a protocol requirement, not a capability fallback: SP_REQUEST
// is a command without an ATT response; SP_DATA and TIME require ATT responses.
static const char *btGattStage = "idle";

static int btWriteComplete(uint16_t connection, const ble_gatt_error *error,
                           ble_gatt_attr *attribute, void *arg) {
  (void)connection;
  (void)attribute;
  auto *task = static_cast<NimBLETaskData *>(arg);
  *static_cast<uint16_t *>(task->m_pBuf) = error->att_handle;
  NimBLEUtils::taskRelease(*task, error->status);
  return 0;
}

static bool writeBt(NimBLERemoteCharacteristic *c, const uint8_t *d, size_t n,
                    bool withResponse) {
  if (!c || !d || !n || btTransactionCancelled() ||
      !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
      !btClientConnected.load(std::memory_order_acquire)) return false;
  if (withResponse ? !c->canWrite() : !c->canWriteNoResponse()) return false;
  const uint16_t mtu = btClient->getMTU();
  Serial.printf("BT: %s %s header=0x%02x bytes=%u MTU=%u\n", btGattStage,
                withResponse ? "write-response" : "write-no-response", d[0], (unsigned)n, mtu);
  // These protocol packets are single ATT writes. NimBLE's writeValue() can
  // fall back to a truncated prefix when a peer rejects Prepare/Execute Write.
  // Never report delivery of a partial packet or silently change its write mode.
  if (mtu < 3 || n > (size_t)(mtu - 3)) {
    Serial.printf("BT: %s rejected: %u-byte packet requires MTU >= %u\n",
                  btGattStage, (unsigned)n, (unsigned)(n + 3));
    return false;
  }
  int status = BLE_HS_ENOTCONN;
  uint16_t errorHandle = 0;
  for (unsigned attempt = 0; attempt < 2; ++attempt) {
    if (btTransactionCancelled() || !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
        !btClientConnected.load(std::memory_order_acquire)) return false;
    if (!withResponse) {
      status = ble_gattc_write_no_rsp_flat(btClient->getConnHandle(), c->getHandle(), d, n);
    } else {
      NimBLETaskData task(nullptr, 0, &errorHandle);
      status = ble_gattc_write_flat(btClient->getConnHandle(), c->getHandle(), d, n,
                                   btWriteComplete, &task);
      if (status == 0) {
        // Keep callback storage alive until ATT completes or GAP cancels it.
        // The independent host monitor requests GAP disconnect for deadline or loss of clock trust
        // or the total transaction deadline. Do not return on a local timeout:
        // the library callback still references this stack-local task.
        NimBLEUtils::taskWait(task, BLE_NPL_TIME_FOREVER);
        status = task.m_flags;
      }
      if (status == BLE_HS_EDONE) status = 0;
    }
    if (status == 0) {
      // WNR success confirms local submission only; WR success is an ATT ack.
      if (withResponse) ++btWriteAcknowledgements;
      return true;
    }
    const bool needsSecurity = status == BLE_HS_ATT_ERR(BLE_ATT_ERR_INSUFFICIENT_AUTHEN) ||
                               status == BLE_HS_ATT_ERR(BLE_ATT_ERR_INSUFFICIENT_AUTHOR) ||
                               status == BLE_HS_ATT_ERR(BLE_ATT_ERR_INSUFFICIENT_ENC);
    if (attempt == 0 && withResponse && needsSecurity && !btTransactionCancelled() &&
        btClientPreemptionEnabled.load(std::memory_order_acquire) &&
        btClientConnected.load(std::memory_order_acquire) && btClient->secureConnection()) {
      Serial.printf("BT: %s retrying full packet after securing connection\n", btGattStage);
      continue;
    }
    break;
  }
  Serial.printf("BT: %s GATT %s failed (UUID=%s status=%d/0x%04x error-handle=0x%04x)\n",
                btGattStage, withResponse ? "write-response" : "write-no-response",
                c->getUUID().toString().c_str(), status, (unsigned)status, errorHandle);
  if (status >= 0x100 && status < 0x200)
    Serial.printf("BT: ATT error=0x%02x\n", status - 0x100);
  return false;
}

static void disconnectGShock(void) {
  cancelBtResponse();
  btClientPreemptionEnabled.store(false, std::memory_order_release);
  if (btClient && !btClientQuiescent()) {
    if (!requestBtClientTermination())
      Serial.println("BT: client termination request failed; retaining client");
    const uint32_t started = millis();
    while (!btClientQuiescent() && millis() - started < 2000UL) {
      // A late onConnect after cancelConnect resets the request guard, allowing
      // this wait to terminate the established connection safely as well.
      requestBtClientTermination();
      delay(5);
    }
    if (!btClientQuiescent())
      Serial.println("BT: teardown barrier timeout; reconnect remains blocked");
  }
  // These aliases are owned by loop(); clearing them never destroys NimBLE's
  // retained service objects. Cache destruction happens only on a later safe
  // reconnect, after the host barrier and all synchronous GATT calls returned.
  btService = nullptr;
  btSpRequest = nullptr;
  btSpData = nullptr;
  btSetChar = nullptr;
  btBleBusy = !btClientQuiescent();
  if (!btBleBusy) btTransactionActive.store(false, std::memory_order_release);
  serviceBtClientQuarantine();
  applicationProgressCheckpoint();
}

static bool validateBtCharacteristic(const char *label, const char *uuid,
                                     NimBLERemoteCharacteristic *c, bool withResponse) {
  if (!c) {
    Serial.printf("BT: %s missing (UUID=%s)\n", label, uuid);
    return false;
  }
  String properties;
  if (c->canWriteNoResponse()) properties += "write-no-response ";
  if (c->canWrite()) properties += "write-response ";
  if (c->canNotify()) properties += "notify ";
  if (c->canIndicate()) properties += "indicate ";
  properties.trim();
  if (!properties.length()) properties = "no supported properties";
  Serial.printf("BT: %s found [%s]\n", label, properties.c_str());
  if (withResponse ? !c->canWrite() : !c->canWriteNoResponse()) {
    Serial.printf("BT: %s wrong properties (requires %s; UUID=%s)\n", label,
                  withResponse ? "write-response" : "write-no-response", uuid);
    return false;
  }
  return true;
}

static bool connectGShock(int protocol) {
  if (btLastWatchAddress.length() != 17 || !btBleInitialized || bleOperationCancelled()) return false;
  if (btClient && !btClientQuiescent()) {
    disconnectGShock();
    if (!btClientQuiescent()) return false;
  }
  if (!bluetoothMemoryAvailable()) {
    Serial.println("BT: connection deferred: insufficient internal memory");
    return false;
  }
  applicationProgressCheckpoint();
  btTransactionStartedMillis.store(millis(), std::memory_order_relaxed);
  btTransactionActive.store(true, std::memory_order_release);
  btBleBusy = true;
  setBluetoothPhase("Connecting");
  if (!btClient) {
    btClient = NimBLEDevice::createClient();
    if (!btClient) {
      btBleBusy = false;
      btTransactionActive.store(false, std::memory_order_release);
      Serial.println("BT: NimBLE client allocation failed");
      return false;
    }
    btClient->setClientCallbacks(&gshockClientCallbacks, false);
    btClient->setSelfDelete(false, false);
    btClient->setConnectTimeout(5000);
    btClient->setConnectRetries(0); // Cancellation and each attempt stay bounded.
  }
  if (!initializeBtClientBarrier()) {
    btBleBusy = false;
    btTransactionActive.store(false, std::memory_order_release);
    return false;
  }
  if (protocol == BT_PROTOCOL_BX5600_MIP && !NimBLEDevice::setMTU(517)) {
    Serial.println("BT: preferred ATT MTU setup failed");
    disconnectGShock();
    return false;
  }
  btClientTerminationRequested.store(false, std::memory_order_release);
  ++btConnectionAttempts;
  btClientQuiescentReady.store(false, std::memory_order_release);
  btClientConnectionPending.store(true, std::memory_order_release);
  NimBLEAddress peer(std::string(btLastWatchAddress.c_str()), btLastWatchAddressType);
  // Start asynchronously so deadline/clock loss can cancel promptly.
  // deleteAttributes=true refreshes the cache only after the previous barrier.
  if (!btClient->connect(peer, true, true)) {
    btClientConnectionPending.store(false, std::memory_order_release);
    btClientQuiescentReady.store(true, std::memory_order_release);
    Serial.println("BT: connection could not be started");
    disconnectGShock();
    return false;
  }
  btClientPreemptionEnabled.store(true, std::memory_order_release);
  if (ble_npl_callout_reset(&btClientPreemptionCallout, ble_npl_time_ms_to_ticks32(20)) != BLE_NPL_OK) {
    Serial.println("BT: transaction deadline monitor could not start; connection cancelled");
    disconnectGShock();
    return false;
  }
  const uint32_t started = millis();
  while (btClientConnectionPending.load(std::memory_order_acquire) &&
         !btTransactionCancelled() && millis() - started < 5500UL) delay(5);
  if (btTransactionCancelled() || !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
      !btClientConnected.load(std::memory_order_acquire)) {
    Serial.println("BT: connection cancelled, timed out or failed");
    disconnectGShock();
    return false;
  }
  if (protocol == BT_PROTOCOL_BX5600_MIP) {
    // onConnect may precede asynchronous MTU completion. Largest SP packet is
    // 133 bytes and must fit in a single Write Request (MTU >= 136).
    const uint32_t mtuStarted = millis();
    while (btClient->getMTU() < CasioBxProtocol::kMinimumMtu &&
           !btTransactionCancelled() && btClientConnected.load(std::memory_order_acquire) &&
           btClientPreemptionEnabled.load(std::memory_order_acquire) &&
           millis() - mtuStarted < 2000UL) delay(5);
    Serial.printf("BT: GW-BX5600 ATT MTU=%u (required >= %u)\n",
                  btClient->getMTU(), (unsigned)CasioBxProtocol::kMinimumMtu);
    if (btClient->getMTU() < CasioBxProtocol::kMinimumMtu) {
      Serial.println("BT: MTU exchange insufficient; no SP handshake sent");
      disconnectGShock();
      return false;
    }
  }
  btService = btClient->getService(NimBLEUUID(CASIO_WATCH_FEATURES_SERVICE));
  if (btTransactionCancelled() || !btService) {
    Serial.println("BT: Casio feature service missing or discovery cancelled");
    disconnectGShock();
    return false;
  }
  btSetChar = btService->getCharacteristic(NimBLEUUID(CASIO_SET_CHAR));
  bool valid = validateBtCharacteristic("TIME", CASIO_SET_CHAR, btSetChar, true);
  // Only the BX5600 MIP path needs SP request/response characteristics.
  if (protocol == BT_PROTOCOL_BX5600_MIP && !btTransactionCancelled()) {
    btSpRequest = btService->getCharacteristic(NimBLEUUID(CASIO_SP_REQUEST_CHAR));
    if (!btTransactionCancelled())
      btSpData = btService->getCharacteristic(NimBLEUUID(CASIO_SP_DATA_CHAR));
    const bool requestValid = validateBtCharacteristic("SP_REQUEST", CASIO_SP_REQUEST_CHAR, btSpRequest, false);
    const bool dataValid = validateBtCharacteristic("SP_DATA", CASIO_SP_DATA_CHAR, btSpData, true);
    valid = valid && requestValid && dataValid;
    // Subscribe before sending any request so a fast response cannot be lost.
    bool subscribed = false;
    if (valid && !btTransactionCancelled()) {
      if (btSpData->canNotify()) subscribed = btSpData->subscribe(true, gshockNotifyCallback, true);
      else if (btSpData->canIndicate()) subscribed = btSpData->subscribe(false, gshockNotifyCallback, true);
      if (!subscribed) Serial.println("BT: SP_DATA notification/indication subscription failed");
    }
    valid = valid && subscribed;
  }
  if (!valid || btTransactionCancelled() || !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
      !btClientConnected.load(std::memory_order_acquire)) {
    disconnectGShock();
    return false;
  }
  Serial.println("BT: protocol characteristics OK");
  setBluetoothPhase("Syncing");
  return true;
}

static size_t bxRequest(const uint8_t *req, size_t reqLen, uint8_t header,
                        size_t minimum, uint8_t *out, size_t maxOut) {
  if (!out || maxOut < minimum || btTransactionCancelled()) return 0;
  prepareBtResponse(header);
  if (!writeBt(btSpRequest, req, reqLen, false)) {
    cancelBtResponse();
    ++btResponseErrors;
    return 0;
  }
  if (!waitBt(minimum)) return 0;
  // Do not accept a valid-looking prefix of a response that would be truncated.
  portENTER_CRITICAL(&btResponseMux);
  const size_t received = btResponseLength;
  portEXIT_CRITICAL(&btResponseMux);
  if (received > maxOut || btTransactionCancelled()) {
    ++btResponseErrors;
    return 0;
  }
  size_t len = copyBt(out, maxOut);
  Serial.printf("BT: %s response header=0x%02x bytes=%u\n", btGattStage,
                len ? out[0] : 0, (unsigned)len);
  if (len < minimum || out[0] != header) {
    ++btResponseErrors;
    return 0;
  }
  return len;
}

static bool requestBluetoothBasicSettings(NimBLERemoteCharacteristic *request,
                                          uint8_t *reply, size_t &size) {
  size = 0;
  if (!request || !reply || btTransactionCancelled() ||
      !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
      !btClientConnected.load(std::memory_order_acquire)) return false;
  const uint8_t command[] = {CasioWatchSettings::kBasicHeader};
  prepareBtResponse(command[0]);
  if (!writeBt(request, command, sizeof(command), request->canWrite())) {
    cancelBtResponse(); return false;
  }
  const uint32_t timeout=optionalReplyTimeoutMs(BT_REQUEST_TIMEOUT_MS);
  if (!timeout || !waitBt(CasioWatchSettings::kBxBasicSize,timeout)) return false;
  // Both observed layouts are complete packets. Reject excess bytes before
  // copying so a truncated prefix can never pass as a valid settings reply.
  portENTER_CRITICAL(&btResponseMux);
  const size_t received = btResponseLength;
  const bool overflow = btResponseOverflow;
  portEXIT_CRITICAL(&btResponseMux);
  if (overflow || !CasioWatchSettings::validBasicSize(received) ||
      btTransactionCancelled() ||
      !btClientPreemptionEnabled.load(std::memory_order_acquire) ||
      !btClientConnected.load(std::memory_order_acquire)) return false;
  size = copyBt(reply, BT_RESPONSE_CAPACITY);
  Serial.printf("BT: %s response header=0x%02x bytes=%u\n", btGattStage,
                size ? reply[0] : 0, (unsigned)size);
  return size == received && reply[0] == command[0];
}

static bool readBluetoothWatchBattery(void) {
  if (btTransactionRemainingMs()<20000) {
    btPendingBatteryStatus="Battery read skipped: reserving required handshake/time budget";
    return false;
  }
  String name = btLastWatchName.length() ? btLastWatchName :
                btPairModeActive ? String("") : btProfileName[btActiveProfile];
  name.toUpperCase();
  if (btActiveProtocol != BT_PROTOCOL_BX5600_MIP || name.indexOf("GW-BX5600") < 0 ||
      btLastWatchAddress.length() != 17) {
    btPendingBatteryStatus = "Unavailable: battery reading supports identified GW-BX5600 watches";
    return false;
  }
  const auto ready = []() {
    return !btTransactionCancelled() &&
           btClientPreemptionEnabled.load(std::memory_order_acquire) &&
           btClientConnected.load(std::memory_order_acquire);
  };
  const auto failed = [](const char *reason) {
    btPendingBatteryStatus = reason;
    Serial.printf("BT: battery read unavailable: %s\n", reason);
    return false;
  };
  btGattStage = "BX battery discovery";
  if (!ready() || !btService || !btSetChar)
    return failed("Watch disconnected or shutdown cancelled the battery read");
  auto request = btService->getCharacteristic(NimBLEUUID(CASIO_BASIC_REQUEST_CHAR));
  if (!ready()) return failed("Watch disconnected or shutdown cancelled the battery read");
  if (!request || !request->canWriteNoResponse())
    return failed("Watch-condition request characteristic unavailable");
  btGattStage = "BX battery subscription";
  bool subscribed = false;
  if (btSetChar->canNotify()) subscribed = btSetChar->subscribe(true, gshockNotifyCallback, true);
  else if (btSetChar->canIndicate()) subscribed = btSetChar->subscribe(false, gshockNotifyCallback, true);
  if (!ready()) return failed("Watch disconnected or shutdown cancelled the battery read");
  if (!subscribed) return failed("Watch-condition notification subscription rejected");
  const uint8_t command[] = {CasioWatchBattery::kHeader};
  btGattStage = "BX battery request";
  prepareBtResponse(command[0]);
  // Captures use GET with a Write Command, never an ATT Write Request.
  if (!writeBt(request, command, sizeof(command), false)) {
    cancelBtResponse();
    return failed("Watch-condition request could not be sent");
  }
  if (!waitBt(CasioWatchBattery::kBxResponseSize, CasioWatchBattery::kReplyTimeoutMs))
    return failed("No complete battery reply (timeout, disconnect or shutdown cancellation)");
  portENTER_CRITICAL(&btResponseMux);
  const size_t received = btResponseLength;
  const bool overflow = btResponseOverflow;
  portEXIT_CRITICAL(&btResponseMux);
  uint8_t reply[CasioWatchBattery::kBxResponseSize], percent = 0;
  if (overflow || received != sizeof(reply) || !ready() ||
      copyBt(reply, sizeof(reply)) != received ||
      !CasioWatchBattery::decodeBx(reply, received, percent))
    return failed("Invalid or incomplete watch-condition reply");
  btPendingBattery.available = true;
  btPendingBattery.percent = percent;
  btPendingBattery.sampledUtc = time(nullptr);
  strlcpy(btPendingBattery.address, btLastWatchAddress.c_str(), sizeof(btPendingBattery.address));
  btPendingBatteryStatus = "Read during sync";
  Serial.printf("BT: Watch %u battery estimate %u%% (raw=%u)\n",
                (unsigned)btActiveProfile + 1, percent, reply[1]);
  return true;
}

static void commitBluetoothBattery(void) {
  auto &reading = btBatteryReadings[btActiveProfile];
  // A replacement becomes bound only after TIME succeeds. Do not attach an
  // old watch's reading to a newly paired device when its battery read failed.
  if (btActiveProtocol != BT_PROTOCOL_BX5600_MIP ||
      !reading.matches(btProfileAddress[btActiveProfile].c_str())) reading = {};
  if (btPendingBattery.matches(btProfileAddress[btActiveProfile].c_str()) &&
      btActiveProtocol == BT_PROTOCOL_BX5600_MIP) reading = btPendingBattery;
  btBatteryStatuses[btActiveProfile] = btPendingBatteryStatus;
}

static bool applyBluetoothWatchFont(void) {
  const uint8_t mode = btFontMode[btActiveProfile];
  if (!mode) { btFontLastStatus = "No font override requested"; return true; }
  if (btTransactionRemainingMs()<15000) {
    btFontLastStatus="Font skipped: reserving final TIME write budget";
    return false;
  }
  String name = btLastWatchName.length() ? btLastWatchName :
                btPairModeActive ? String("") : btProfileName[btActiveProfile];
  name.toUpperCase();
  if (name.indexOf("GW-BX5600") < 0 || !btService || !btSetChar) {
    btFontLastStatus = "Font skipped: a GW-BX5600 must be identified";
    Serial.println(btFontLastStatus);
    return false;
  }
  const auto ready = []() {
    return !btTransactionCancelled() &&
           btClientPreemptionEnabled.load(std::memory_order_acquire) &&
           btClientConnected.load(std::memory_order_acquire);
  };
  const auto failed = [](const char *reason) {
    btFontLastStatus = String("Font update failed at ") + btGattStage + ": " + reason;
    Serial.println(btFontLastStatus);
    return false;
  };
  btGattStage = "BX font discovery";
  if (!ready()) return failed("watch disconnected or shutdown cancelled the operation");
  auto request = btService->getCharacteristic(NimBLEUUID(CASIO_BASIC_REQUEST_CHAR));
  if (!ready()) return failed("watch disconnected or shutdown cancelled the operation");
  if (!request || (!request->canWrite() && !request->canWriteNoResponse()))
    return failed("basic-settings request characteristic unavailable");
  btGattStage = "BX font subscription";
  bool subscribed = false;
  if (btSetChar->canNotify()) subscribed = btSetChar->subscribe(true, gshockNotifyCallback, true);
  else if (btSetChar->canIndicate()) subscribed = btSetChar->subscribe(false, gshockNotifyCallback, true);
  if (!ready()) return failed("watch disconnected or shutdown cancelled the operation");
  if (!subscribed) return failed("settings notification subscription rejected");
  uint8_t reply[BT_RESPONSE_CAPACITY], packet[CasioWatchSettings::kBasicSize];
  size_t size = 0;
  btGattStage = "BX font read settings";
  if (!requestBluetoothBasicSettings(request, reply, size) ||
      !CasioWatchSettings::buildFont(reply, size, mode, packet, sizeof(packet)))
    return failed("missing, incomplete or unsupported settings reply");
  if (memcmp(reply, packet, size) != 0) {
    const size_t writtenSize = size;
    btGattStage = "BX font write settings";
    if (!writeBt(btSetChar, packet, writtenSize, true))
      return failed("settings write was not acknowledged");
    btGattStage = "BX font readback";
    if (!requestBluetoothBasicSettings(request, reply, size) ||
        size != writtenSize || memcmp(reply, packet, writtenSize) != 0)
      return failed("settings readback did not match the requested font packet");
  }
  btFontLastStatus = String("Watch ") + (btActiveProfile + 1) + ": " +
                     (mode == 2 ? "Classic" : "Standard (new)") +
                     " font confirmed by settings readback; display unverified";
  Serial.println(btFontLastStatus);
  return true;
}

static bool readWatchFeature(NimBLERemoteCharacteristic *request,uint8_t header,
                             uint8_t *reply,size_t &size) {
  size=0;
  const uint32_t timeout=optionalReplyTimeoutMs();
  if (!request || !reply || !timeout || btTransactionCancelled()) return false;
  prepareBtResponse(header);
  if (!writeBt(request,&header,1,false)) { cancelBtResponse(); return false; }
  const size_t minimum=header==CasioWatchFeatures::kFirstAlarmHeader?5:
                       header==CasioWatchFeatures::kOtherAlarmsHeader?17:
                       header==CasioWatchFeatures::kTimerHeader?6:
                       header==CasioWatchFeatures::kBasicHeader?12:15;
  if (!waitBt(minimum,timeout)) return false;
  portENTER_CRITICAL(&btResponseMux);
  const size_t received=btResponseLength; const bool overflow=btResponseOverflow;
  portEXIT_CRITICAL(&btResponseMux);
  if (overflow || received>CasioWatchFeatures::kMaxPacketSize || btTransactionCancelled()) return false;
  size=copyBt(reply,CasioWatchFeatures::kMaxPacketSize);
  return size==received && size>=minimum && reply[0]==header;
}
static bool featureReplyMatches(uint8_t header,const uint8_t *reply,size_t size,
                                const CasioWatchFeatures::Caps &caps,const CasioWatchFeatures::Desired &d) {
  switch (header) {
    case CasioWatchFeatures::kFirstAlarmHeader: return CasioWatchFeatures::firstAlarmMatches(reply,size,d);
    case CasioWatchFeatures::kOtherAlarmsHeader: return CasioWatchFeatures::otherAlarmsMatch(reply,size,caps.alarmCount,d);
    case CasioWatchFeatures::kTimerHeader: return CasioWatchFeatures::timerMatches(reply,size,d);
    case CasioWatchFeatures::kBasicHeader: return CasioWatchFeatures::basicMatches(reply,size,caps.basicMask,d);
    case CasioWatchFeatures::kAutoAdjustHeader: return CasioWatchFeatures::autoAdjustMatches(reply,size,d);
    default: return false;
  }
}
static bool mergeFeatureReply(uint8_t header,const uint8_t *reply,size_t size,
                              const CasioWatchFeatures::Caps &caps,const CasioWatchFeatures::Desired &d,uint8_t *packet) {
  switch (header) {
    case CasioWatchFeatures::kFirstAlarmHeader: return CasioWatchFeatures::mergeFirstAlarm(reply,size,d,packet,CasioWatchFeatures::kMaxPacketSize);
    case CasioWatchFeatures::kOtherAlarmsHeader: return CasioWatchFeatures::mergeOtherAlarms(reply,size,caps.alarmCount,d,packet,CasioWatchFeatures::kMaxPacketSize);
    case CasioWatchFeatures::kTimerHeader: return CasioWatchFeatures::mergeTimer(reply,size,d,packet,CasioWatchFeatures::kMaxPacketSize);
    case CasioWatchFeatures::kBasicHeader: return CasioWatchFeatures::mergeBasic(reply,size,caps.basicMask,d,packet,CasioWatchFeatures::kMaxPacketSize);
    case CasioWatchFeatures::kAutoAdjustHeader: return CasioWatchFeatures::mergeAutoAdjust(reply,size,d,packet,CasioWatchFeatures::kMaxPacketSize);
    default: return false;
  }
}
static void applyBluetoothWatchFeatures(void) {
  const int profile=btActiveProfile;
  if (profile < 0 || profile >= BT_WATCH_PROFILE_COUNT) return;
  const auto &desired=btFeatureDesired[profile];
  if (!desired.enabled) { btFeatureStatus[profile]="Off: time synchronization only"; return; }
  if (btFeatureBoundProtocol[profile]!=btActiveProtocol ||
      !btLastWatchAddress.equalsIgnoreCase(btFeatureBoundAddress[profile])) {
    btFeatureStatus[profile]="Skipped: choices belong to another watch binding"; return;
  }
  const String &name=btLastWatchName.length()?btLastWatchName:btProfileName[profile];
  const auto caps=CasioWatchFeatures::capabilities(name.c_str(),name.length());
  if (!CasioWatchFeatures::validDesired(desired) ||
      (desired.alarmsEnabled && caps.alarmCount!=CasioWatchFeatures::kAlarmCount) ||
      (desired.hourlyChime>=0 && !caps.hourlyChime) || (desired.basicMask & ~caps.basicMask) ||
      (desired.timerEnabled && (!caps.timer || desired.timerSeconds>caps.timerMaxSeconds)) ||
      (desired.autoAdjustEnabled && !caps.autoAdjust)) {
    btFeatureStatus[profile]="Skipped: model does not support the saved feature selection"; return;
  }
  const bool selected[]={desired.alarmsEnabled || desired.hourlyChime>=0,desired.alarmsEnabled,
                         desired.timerEnabled,desired.basicMask!=0,desired.autoAdjustEnabled};
  const uint8_t headers[]={CasioWatchFeatures::kFirstAlarmHeader,CasioWatchFeatures::kOtherAlarmsHeader,
      CasioWatchFeatures::kTimerHeader,CasioWatchFeatures::kBasicHeader,CasioWatchFeatures::kAutoAdjustHeader};
  unsigned requested=0; for (bool enabled:selected) if (enabled) ++requested;
  if (!requested) { btFeatureStatus[profile]="No optional feature changes selected"; return; }
  // Admit optional groups only while an explicit reserve remains for font and
  // TIME. A hung ATT operation is cancelled by the independent host deadline;
  // no stack-local callback storage is abandoned to pretend TIME succeeded.
  const uint32_t reserve=btFontMode[profile]?15000:5000;
  if (!btService || !btSetChar || btTransactionRemainingMs()<reserve+6500) {
    btFeatureStatus[profile]="Deferred: reserving final TIME write budget"; return;
  }
  auto request=btService->getCharacteristic(NimBLEUUID(CASIO_BASIC_REQUEST_CHAR));
  if (!request || !request->canWriteNoResponse() || btTransactionCancelled()) {
    btFeatureStatus[profile]="Optional settings unavailable: read-request characteristic missing"; return;
  }
  bool subscribed=false;
  if (btSetChar->canNotify()) subscribed=btSetChar->subscribe(true,gshockNotifyCallback,true);
  else if (btSetChar->canIndicate()) subscribed=btSetChar->subscribe(false,gshockNotifyCallback,true);
  if (!subscribed || btTransactionCancelled()) {
    btFeatureStatus[profile]="Optional settings unavailable: notifications not subscribed"; return;
  }
  unsigned confirmed=0,failed=0,deferred=0;
  for (size_t group=0;group<sizeof(headers);++group) {
    if (!selected[group]) continue;
    if (btTransactionCancelled() || btTransactionRemainingMs()<reserve+6500) { ++deferred; continue; }
    uint8_t reply[CasioWatchFeatures::kMaxPacketSize], packet[CasioWatchFeatures::kMaxPacketSize];
    size_t size=0;
    btGattStage="watch features read";
    if (!readWatchFeature(request,headers[group],reply,size) ||
        !mergeFeatureReply(headers[group],reply,size,caps,desired,packet)) {
      ++failed; Serial.printf("BT features: header0x%02x missing or unsupported reply; no write\n",headers[group]); continue;
    }
    if (!featureReplyMatches(headers[group],reply,size,caps,desired)) {
      // Recheck before each ATT submission/readback, since preceding work may
      // have consumed the reserve. Keep all unknown watch bytes untouched.
      if (btTransactionRemainingMs()<reserve+4000) { ++deferred; continue; }
      btGattStage="watch features write";
      if (!writeBt(btSetChar,packet,size,true)) { ++failed; continue; }
      if (btTransactionRemainingMs()<reserve+1500) { ++deferred; continue; }
      btGattStage="watch features readback";
      size_t readbackSize=0;
      if (!readWatchFeature(request,headers[group],reply,readbackSize) || readbackSize!=size ||
          !featureReplyMatches(headers[group],reply,readbackSize,caps,desired)) {
        ++failed; Serial.printf("BT features: header0x%02x readback failed; TIME remains separate\n",headers[group]); continue;
      }
    }
    ++confirmed;
  }
  btFeatureStatus[profile]=confirmed==requested?"Requested settings confirmed by watch readback; display unverified":
    failed?"Some settings failed or were unconfirmed; time result is separate":
    confirmed?"Some settings confirmed; remaining changes deferred by time budget":
              "Deferred: reserving final TIME write budget";
  Serial.printf("BT features: Watch%u confirmed%u failed%u deferred%u of%u groups\n",
                profile+1,confirmed,failed,deferred,requested);
}

bool performGShockBX5600Sync(void) {
  if (!connectGShock(BT_PROTOCOL_BX5600_MIP)) return false;
  // The manual D-button captures read condition before the SP handshake.
  // A battery failure is optional; the required time handshake still runs.
  readBluetoothWatchBattery();
  uint8_t r[BT_RESPONSE_CAPACITY];
  uint8_t cities[CasioBxProtocol::kCitiesSize];
  uint8_t settings[CasioBxProtocol::kSettingsWriteSize];
  uint8_t dst[CasioBxProtocol::kDstWriteSize];
  bool ok = false;

  do {
    btGattStage = "BX step 1 settings";
    const uint8_t req1[] = {0x05,0x1D,0x00,0x1D,0x00,0x24,0x00,0x24,0x01,0x24,0x02};
    size_t n1 = bxRequest(req1, sizeof(req1), 0x05, 101, r, sizeof(r));
    if (!n1) break;
    if (!CasioBxProtocol::splitSettings(r, n1, settings, sizeof(settings), cities, sizeof(cities))) {
      Serial.println("BT: BX step 1 malformed settings/city records");
      ++btResponseErrors;
      break;
    }
    // Send only the two 0x1D records; save the three 0x24 city records for step 2.
    if (!writeBt(btSpData, settings, sizeof(settings), true)) break;

    btGattStage = "BX step 2 DST/cities";
    const uint8_t req2[] = {0x03,0x1E,0x00,0x1E,0x00,0x1E,0x00};
    size_t n2 = bxRequest(req2, sizeof(req2), 0x03, 28, r, sizeof(r));
    if (!n2) break;
    if (!CasioBxProtocol::buildDst(r, n2, cities, sizeof(cities), dst, sizeof(dst))) {
      Serial.println("BT: BX step 2 malformed DST/city records");
      ++btResponseErrors;
      break;
    }
    if (!writeBt(btSpData, dst, sizeof(dst), true)) break;

    btGattStage = "BX step 3 alarms";
    uint8_t req3[13] = {0x06};
    for (int i = 0; i < 6; ++i) {
      int idx = (i / 2) + ((i % 2) ? 6 : 0);
      req3[1 + i * 2] = 0x1F;
      req3[2 + i * 2] = (uint8_t)idx;
    }
    size_t n3 = bxRequest(req3, sizeof(req3), 0x06, 133, r, sizeof(r));
    if (!n3) break;
    if (!CasioBxProtocol::validAlarms(r, n3)) {
      Serial.println("BT: BX step 3 malformed alarm records");
      ++btResponseErrors;
      break;
    }
    if (!writeBt(btSpData, r, n3, true)) break;

    // A watch-triggered time session can close immediately after TIME is
    // acknowledged. Apply optional settings first; a font failure alone must
    // not prevent a time attempt. Sample time only after this optional work.
    applyBluetoothWatchFeatures();
    applyBluetoothWatchFont();
    if (!clockTrusted() || btTransactionCancelled()) break;
    struct timeval tv;
    gettimeofday(&tv, nullptr);
    time_t epoch = tv.tv_sec;
    struct tm local;
    bluetoothLocalTime(epoch, local);
    int year = local.tm_year + 1900;
    uint8_t tc[11] = {
      0x09,(uint8_t)(year&255),(uint8_t)((year>>8)&255),
      (uint8_t)(local.tm_mon+1),(uint8_t)local.tm_mday,
      (uint8_t)local.tm_hour,(uint8_t)local.tm_min,(uint8_t)local.tm_sec,
      (uint8_t)(local.tm_wday==0?7:local.tm_wday),
      (uint8_t)((tv.tv_usec/1000UL*256UL)/1000UL),0x01
    };
    btGattStage = "BX step 4 TIME";
    if (!writeBt(btSetChar, tc, sizeof(tc), true)) break;

    ok = true;
    btDeliveryEvidence = "ATT write acknowledged; watch display unverified";
    Serial.printf("BT: GW-BX5600 time command delivered %04d-%02d-%02d %02d:%02d:%02d\n",
                  year, local.tm_mon+1, local.tm_mday,
                  local.tm_hour, local.tm_min, local.tm_sec);
  } while (false);

  disconnectGShock();
  btGattStage = "idle";
  return ok;
}

bool performCasioStandardTimeSync(int protocol) {
  if (protocol != BT_PROTOCOL_STANDARD && protocol != BT_PROTOCOL_ANALOGUE) return false;
  if (!connectGShock(protocol)) return false;
  applyBluetoothWatchFeatures();
  if (!clockTrusted() || btTransactionCancelled()) {
    disconnectGShock();
    btGattStage = "idle";
    return false;
  }
  struct timeval tv;
  gettimeofday(&tv, nullptr);
  time_t epoch = tv.tv_sec;
  struct tm local;
  bluetoothLocalTime(epoch, local);
  int year = local.tm_year + 1900;
  uint8_t tc[CasioStandardProtocol::PacketSize];
  if (!CasioStandardProtocol::encode(local, tv.tv_usec, tc)) {
    Serial.println("BT: invalid civil time sample; TIME write cancelled");
    disconnectGShock();
    return false;
  }
  btGattStage = "Casio TIME";
  bool ok = writeBt(btSetChar, tc, sizeof(tc), true);
  if (ok) btDeliveryEvidence = "ATT write acknowledged; watch display unverified";
  if (ok) Serial.printf("BT: %s time write acknowledged, %04d-%02d-%02d %02d:%02d:%02d\n",
                        btProtocolName(protocol), year, local.tm_mon + 1, local.tm_mday,
                        local.tm_hour, local.tm_min, local.tm_sec);
  disconnectGShock();
  btGattStage = "idle";
  return ok;
}

bool attemptBluetoothSync(void) {
  btPendingBattery = {};
  btPendingBatteryStatus = btActiveProtocol == BT_PROTOCOL_BX5600_MIP
                            ? "Not read during this sync"
                            : "Unavailable: selected protocol has no validated battery reading";
  btFontLastStatus = btFontMode[btActiveProfile] && btActiveProtocol != BT_PROTOCOL_BX5600_MIP
                    ? "Font skipped: selected protocol does not support this option"
                    : "No font override requested";
  if (!clockTrusted()) {
    btLastSyncStatus = "Blocked: NTP clock not trusted; awaiting a confirmed SNTP update";
    return false;
  }
  if (bleOperationCancelled() || !btControllerStarted) {
    btLastSyncStatus = "Deferred: Bluetooth shutdown/recovery pending";
    return false;
  }
  const int protocol = btActiveProtocol;
  Serial.printf("BT: connecting with %s time-only protocol\n", btProtocolName(protocol));
  bool ok = (protocol == BT_PROTOCOL_BX5600_MIP)
              ? performGShockBX5600Sync() : performCasioStandardTimeSync(protocol);
  if (ok) {
    time_t syncEpoch=time(nullptr); struct tm syncLocal; bluetoothLocalTime(syncEpoch,syncLocal);
    bool bindingChanged = false;
    btSuccessYear[protocol] = syncLocal.tm_year + 1900;
    btSuccessYday[protocol] = syncLocal.tm_yday;
    btProfileSuccessYear[btActiveProfile] = syncLocal.tm_year + 1900;
    btProfileSuccessYday[btActiveProfile] = syncLocal.tm_yday;
    if (btPairModeActive) {
      bindingChanged = btProfileAddress[btActiveProfile] != btLastWatchAddress ||
                       btProfileName[btActiveProfile] != btLastWatchName ||
                       btProfileProtocol[btActiveProfile] != btActiveProtocol;
      btProfileAddress[btActiveProfile] = btLastWatchAddress;
      btProfileName[btActiveProfile] = btLastWatchName;
      btProfileProtocol[btActiveProfile] = btActiveProtocol;
    }
    commitBluetoothBattery();
    btSyncDayComplete = true;
    if (protocol == BT_PROTOCOL_BX5600_MIP) {
      btSyncLastYear = btSuccessYear[protocol];
      btSyncLastYday = btSuccessYday[protocol];
    }
    char d[24]; strftime(d,sizeof(d),"%Y-%m-%d %H:%M:%S",&syncLocal);
    btLastSyncDate = d;
    btLastSyncStatus = String("Watch ") + (btActiveProfile+1) + ": " + btProtocolName(protocol) + " - time write delivered (watch unverified)";
    btLastSyncEpoch.store((uint32_t)syncEpoch, std::memory_order_release);
    btLastOutcomeSuccessful.store(true, std::memory_order_release);
    btProtocolLastSyncEpoch[protocol] = (uint32_t)syncEpoch;
    btProfileLastSyncEpoch[btActiveProfile] = (uint32_t)syncEpoch;
    btProfileLastSyncProtocol[btActiveProfile] = btActiveProtocol;
    btProfileLastSyncAddress[btActiveProfile] = btLastWatchAddress;
    btRecentSyncs.bind(btActiveProfile, btProfileAddress[btActiveProfile].c_str(), btProfileProtocol[btActiveProfile]);
    btRecentSyncs.record(btActiveProfile, btLastWatchAddress.c_str(), btActiveProtocol,
                        static_cast<uint32_t>(syncEpoch), true);
    // Binding changes remain required configuration; routine history is not.
    if (bindingChanged) saveConfig();
    saveBluetoothHistoryNow(syncEpoch);
  } else {
    btLastSyncStatus = String(btProtocolName(protocol)) + " - sync attempt failed";
    btLastOutcomeSuccessful.store(false, std::memory_order_release);
    if (!bleOperationCancelled()) {
      // Shutdown deferrals and an unconfirmed replacement watch are not failures
      // belonging to the bound watch. An untrusted timestamp is shown unknown.
      const uint32_t failedEpoch = clockTrusted() ? static_cast<uint32_t>(time(nullptr)) : 0;
      btRecentSyncs.bind(btActiveProfile, btProfileAddress[btActiveProfile].c_str(), btProfileProtocol[btActiveProfile]);
      btRecentSyncs.record(btActiveProfile, btLastWatchAddress.c_str(), btActiveProtocol, failedEpoch, false);
    }
  }
  return ok;
}

static bool bluetoothControllerNeeded(void) {
  if (btAlwaysWaitEnabled || btPairRequested || btManualSyncRequested ||
      btWindowActive || btBleBusy || btPairModeActive) return true;
  time_t epoch = time(nullptr); struct tm local; bluetoothLocalTime(epoch, local);
  for (int i = 0; i < BT_SYNC_SLOT_COUNT; ++i) {
    if (!btSyncEnabled[i] || !btMinuteInBluetoothWindow(btMinutesOfDay(local), btSyncTimes[i])) continue;
    int year, yday; btSlotOccurrenceDate(i, local, year, yday);
    if (btSlotAttemptYear[i] != year || btSlotAttemptYday[i] != yday) return true;
  }
  return false;
}

static bool shutdownIdleBluetooth(void) {
  if (!btControllerStarted) {
    btShutdownRequested.store(false, std::memory_order_release);
    completeBtShutdownProgress();
    setBluetoothPhase("Bluetooth idle power saving");
    return true;
  }
  if (!serviceBtShutdownProgress()) return false;
  if (btBleBusy || !btClientQuiescent() ||
      (btShutdownRetryMillis && (long)(millis() - btShutdownRetryMillis) < 0)) return false;
  stopBluetoothWindow();
  if (!btScanControl.quiescent()) {
    btShutdownRetryMillis = millis() + 1000;
    setBluetoothPhase("Bluetooth scan shutdown pending");
    return false;
  }
  releaseBtClientBarrier();
  const bool stopped = NimBLEDevice::isInitialized() ? NimBLEDevice::deinit(false)
                                                    : stopPartiallyInitializedBluetooth();
  const bool off = stopped && !NimBLEDevice::isInitialized() &&
                   esp_bt_controller_get_status() == ESP_BT_CONTROLLER_STATUS_IDLE;
  btBleInitialized = NimBLEDevice::isInitialized();
  if (!off) {
    btShutdownRetryMillis = millis() + 1000;
    setBluetoothPhase("Bluetooth idle shutdown failed");
    return false; // Retain ownership until the physical controller is off.
  }
  btShutdownRetryMillis = 0;
  btScanControl.releaseAfterHostStop();
  completeBtShutdownProgress();
  btControllerStarted = false;
  btShutdownRequested.store(false, std::memory_order_release);
  setBluetoothPhase("Bluetooth idle power saving");
  Serial.println("BT: host/controller OFF between listening windows");
  return true;
}

void serviceBluetoothSync(void) {
  if (btShutdownRequested.load() || (!btBleInitialized && btControllerStarted)) {
    recoverBluetoothControllerShutdown();
    return;
  }
  // Settings/explicit requests can change while a failed idle shutdown is
  // recovering. Finish that same bounded episode before admitting new work.
  if (btShutdownRecoveryActive) {
    shutdownIdleBluetooth();
    return;
  }
  if (btIdlePowerSaveEnabled && !bluetoothControllerNeeded()) {
    shutdownIdleBluetooth();
    return;
  }
  if (!btBleInitialized) initBluetoothSync();
  if (!btBleInitialized || bleOperationCancelled()) return;
  resetBluetoothDayIfNeeded();
  if (!serviceBtClientQuarantine()) {
    setBluetoothPhase("Bluetooth disconnect recovery pending");
    return;
  }
  // A previously timed-out host teardown may finish later. Only loopTask can
  // clear the quarantine, after the queued GAP barrier completes.
  if (btBleBusy && btClientQuiescent()) disconnectGShock();
  if (!btBleBusy && !bluetoothMemoryAvailable()) {
    if (!btScanControl.stop()) {
      btShutdownRequested = true;
      serviceBtShutdownProgress();
    }
    setBluetoothPhase("Bluetooth deferred: low internal memory");
    return;
  }

  if (btPairRequested && !btBleBusy) {
    stopBluetoothWindow();
    btPairRequested = false;
    btManualSyncRequested = false;
    btPairModeActive = true;
    btLastSyncStatus = String("Pairing Watch ") + (btManualProfile + 1);
    startBluetoothWindow(-1);
  } else if (btManualSyncRequested && !btBleBusy) {
    // Serialized on loopTask: stop callbacks, discard stale discovery, and
    // reopen the window. Repeated HTTP requests never delete a client.
    stopBluetoothWindow();
    btManualSyncRequested = false;
    btLastSyncStatus = "Waiting for watch";
    startBluetoothWindow(-1);
  }

  // Scheduled windows can preempt passive Always Wait, preserving the selected
  // manual profile. They cannot preempt an explicit manual/pairing window.
  if (!btBleBusy && (!btWindowActive || btPersistentWaitActive)) {
    time_t epoch=time(nullptr); struct tm local; bluetoothLocalTime(epoch,local);
    int nm = btMinutesOfDay(local);
    for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) {
      if (!btMinuteInBluetoothWindow(nm, btSyncTimes[i])) {
        continue;
      }
      if (!btSyncEnabled[i]) continue;
      int occurrenceYear, occurrenceYday;
      btSlotOccurrenceDate(i, local, occurrenceYear, occurrenceYday);
      if (btSlotAttemptYear[i]==occurrenceYear && btSlotAttemptYday[i]==occurrenceYday) continue;
      // Invalid automatic slots stay retryable without repeatedly stopping
      // passive listening for a different, correctly paired watch.
      if (!bluetoothProfileBindingReady(btSyncProfile[i], btSyncProtocol[i])) {
        if (!btWindowActive) {
          btLastSyncStatus = "Pair Watch first for the scheduled profile and protocol";
          setBluetoothPhase("No watch paired");
        }
        continue;
      }
      stopBluetoothWindow();
      startBluetoothWindow(i);
      if (btWindowActive) break;
    }
  }

  if (btPersistentWaitActive && !btAlwaysWaitEnabled) stopBluetoothWindow();
  if (!btWindowActive && !btBleBusy && btAlwaysWaitEnabled &&
      btProfileAddress[btManualProfile].length() == 17 &&
      btProfileProtocol[btManualProfile] == btManualProtocol) startBluetoothWindow(-1, true);

  if (btWindowActive && !btBleBusy) {
    if (!btPersistentWaitActive && (long)(millis()-btWindowEndMillis) >= 0) {
      stopBluetoothWindow();
      btLastSyncStatus = String(btProtocolName(btActiveProtocol)) + " - no watch connection";
      setBluetoothPhase("Idle");
      return;
    }
    String discoveredName, discoveredAddress; uint8_t discoveredType = 0xFF;
    if (consumeBtDiscovery(discoveredName, discoveredAddress, discoveredType)) {
      if (!btScanControl.stop()) {
        btShutdownRequested = true;
        serviceBtShutdownProgress();
        btLastSyncStatus = "Bluetooth scan teardown pending; connection deferred";
        return;
      }
      btLastWatchName = discoveredName;
      btLastWatchAddress = discoveredAddress;
      btLastWatchAddressType = discoveredType;
      btWindowActive = false;
      bool ok = attemptBluetoothSync();
      if (bleOperationCancelled()) {
        // Preserve interrupted request state until shutdown capture.
        btWindowActive = true;
        recoverBluetoothControllerShutdown();
      } else if (!ok) {
        btLastWatchAddress = "";
        clearBtDiscovery();
        btWindowActive = true;
        setBluetoothPhase(btPairModeActive ? "Pairing" : "Waiting for watch");
      } else {
        stopBluetoothWindow();
        setBluetoothPhase("Idle");
      }
      return;
    }
    if (btScan && !bleOperationCancelled() && !btScan->isScanning()) {
      if (!btScanControl.start()) {
        if (!btScanControl.quiescent()) {
          btShutdownRequested = true;
          serviceBtShutdownProgress();
        }
        btLastSyncStatus = "Bluetooth scan start failed";
        setBluetoothPhase("Waiting for watch");
      } else if (!btPairModeActive && btSyncActiveSlot < 0) setBluetoothPhase("Scanning");
    }
  }
}


void initFilesystem(void)
{
  filesystemAvailable = LittleFS.begin(false);
  configStorageFault = !filesystemAvailable;
  if (!filesystemAvailable) {
    Serial.println("LittleFS mount failed; saved settings preserved. Setup AP provides explicit storage recovery.");
    return;
  }
  Serial.println("LittleFS Mounted Successfully");
}

static const char* configTimezoneName(const char *name)
{
  const char *zones[] = {"Asia/Tokyo", "Australia/Brisbane", "Australia/Sydney", "Asia/Shanghai",
                         "Europe/London", "America/New_York", "America/Los_Angeles", "UTC"};
  for (const char *zone : zones) if (!strcmp(name,zone)) return zone;
  return nullptr;
}


static bool validateSavedConfig(const CasioConfigRecord &candidate) {
  static_assert(BT_SYNC_SLOT_COUNT==4 && BT_WATCH_PROFILE_COUNT==4 && BT_PROTOCOL_COUNT==3,
                "Update CasioSync schema before changing saved field counts");
  if (!candidate.versioned() || candidate.count()!=CasioConfigFormat::FIELD_COUNT ||
      strlen(candidate.text(0))>32 || strlen(candidate.text(1))>63 ||
      !configTimezoneName(candidate.text(2))) return false;
  auto numeric = [&candidate](size_t index, int32_t lo, int32_t hi) {
    int32_t value; return CasioConfigRecord::signedInteger(candidate.text(index),lo,hi,value);
  };
  auto boolean = [&candidate](size_t index) { return CasioConfigRecord::boolean(candidate.text(index)); };
  if (!numeric(3,0,1)) return false;
  for (size_t i=4;i<=7;++i) if (!boolean(i)) return false;
  for (size_t i=8;i<=12;++i) if (!numeric(i,0,BT_PROTOCOL_COUNT-1)) return false;
  for (size_t i=13;i<=16;++i) if (!numeric(i,0,1439)) return false;
  for (size_t i=17;i<=21;++i) if (!numeric(i,0,BT_WATCH_PROFILE_COUNT-1)) return false;
  for (size_t i=22;i<=25;++i) {
    const char *address=candidate.text(i);
    if (!*address) continue;
    if (strlen(address)!=17) return false;
    for (size_t pos=0;pos<17;++pos) {
      const char c=address[pos];
      if (pos%3==2) { if (c!=':') return false; }
      else if (!((c>='0'&&c<='9')||(c>='A'&&c<='F')||(c>='a'&&c<='f'))) return false;
    }
  }
  for (size_t i=26;i<=29;++i) if (strlen(candidate.text(i))>=48) return false;
  if (!boolean(30)) return false;
  for (size_t i=31;i<=34;++i) if (!numeric(i,0,BT_PROTOCOL_COUNT-1)) return false;
  if (!configTimezoneName(candidate.text(35)) || !numeric(36,-720,840) || !boolean(37)) return false;
  for (size_t i=38;i<=41;++i) if (!numeric(i,0,2)) return false;
  if (!boolean(42)||!boolean(43)||!boolean(45)||!boolean(49)) return false;
  uint32_t generation;
  if (!CasioConfigRecord::unsignedInteger(candidate.text(44),generation) ||
      !numeric(46,0,1439)||!numeric(47,0,1439)||!configTimezoneName(candidate.text(48)) ||
      !CasioWifiAccessWindow::validMinutes(candidate.number(46,1080),candidate.number(47,1200))) return false;
  return true;
}

static bool configFileLayoutValid(File &file, CasioConfigRecord &candidate)
{
  const size_t size = file.size();
  if (!size || size >= sizeof(storageSerializationBuffer) ||
      file.read(reinterpret_cast<uint8_t *>(storageSerializationBuffer),size) != size) return false;
  storageSerializationBuffer[size] = '\0';
  return candidate.parse(storageSerializationBuffer,size) && validateSavedConfig(candidate);
}

static bool configStringsAvailable(const CasioConfigRecord &candidate) {
  if (!timezone_name.reserve(strlen(candidate.text(2))) ||
      !btTimezoneName.reserve(strlen(candidate.text(35))) ||
      !wifiAccessTimezone.reserve(strlen(candidate.text(48)))) return false;
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i)
    if (!btProfileAddress[i].reserve(strlen(candidate.text(22+i))) ||
        !btProfileName[i].reserve(strlen(candidate.text(26+i)))) return false;
  return true;
}

static void configDefaults(void) {
  ssid[0]=passwd[0]='\0'; timezone_name=DEFAULT_TZ_NAME;
  wifiPowerMode=WIFI_POWER_ALWAYS_ON;
  activityLedEnabled=true; btAlwaysWaitEnabled=true; btIdlePowerSaveEnabled=false;
  btHistoryPersistEnabled=true; btHistoryGeneration=0; crashDumpEnabled=false;
  RadioCrashDumpGate::setEnabled(false);
  wifiAccessEnabled=false; wifiAccessStart=1080; wifiAccessEnd=1200;
  wifiAccessTimezone="Australia/Brisbane"; btTimezoneName=DEFAULT_BT_TIMEZONE; btTimeOffsetMinutes=0;
  btManualProtocol=BT_PROTOCOL_BX5600_MIP; btManualProfile=0;
  const int defaultTimes[]={30,390,750,1110};
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) {
    btSyncEnabled[i]=true; btSyncTimes[i]=defaultTimes[i];
    btSyncProtocol[i]=BT_PROTOCOL_BX5600_MIP; btSyncProfile[i]=0;
  }
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    btFontMode[i]=0; btProfileAddress[i]=""; btProfileName[i]="";
    btProfileProtocol[i]=BT_PROTOCOL_BX5600_MIP;
  }
}

void loadConfig(void) {
  CasioConfigRecord candidate;
  File file;
  if (filesystemAvailable) file=LittleFS.open(CONFIG_FILE,"r");
  const bool exists=(bool)file;
  const bool valid=exists && configFileLayoutValid(file,candidate) && configStringsAvailable(candidate);
  if (file) file.close();
  configDefaults();
  if (!valid) {
    if (exists) {
      configStorageFault=true;
      Serial.println("CasioSync config failed integrity/validation; preserved file, safe defaults and setup AP selected");
    }
    loadBluetoothHistory(); loadWatchOptions(); return;
  }
  configStorageFault=false;
  strlcpy(ssid,candidate.text(0),sizeof(ssid)); strlcpy(passwd,candidate.text(1),sizeof(passwd));
  timezone_name=configTimezoneName(candidate.text(2)); wifiPowerMode=candidate.number(3,0);
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) {
    btSyncEnabled[i]=candidate.flag(4+i,true); btSyncProtocol[i]=candidate.number(8+i,0);
    btSyncTimes[i]=candidate.number(13+i,btSyncTimes[i]); btSyncProfile[i]=candidate.number(17+i,0);
  }
  btManualProtocol=candidate.number(12,0); btManualProfile=candidate.number(21,0);
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    btProfileAddress[i]=candidate.text(22+i); btProfileName[i]=candidate.text(26+i);
    btProfileProtocol[i]=candidate.number(31+i,0); btFontMode[i]=candidate.number(38+i,0);
  }
  btAlwaysWaitEnabled=candidate.flag(30,true); btTimezoneName=configTimezoneName(candidate.text(35));
  btTimeOffsetMinutes=candidate.number(36,0); activityLedEnabled=candidate.flag(37,true);
  btIdlePowerSaveEnabled=candidate.flag(42,false); btHistoryPersistEnabled=candidate.flag(43,true);
  CasioConfigRecord::unsignedInteger(candidate.text(44),btHistoryGeneration);
  wifiAccessEnabled=candidate.flag(45,false); wifiAccessStart=candidate.number(46,1080);
  wifiAccessEnd=candidate.number(47,1200); wifiAccessTimezone=configTimezoneName(candidate.text(48));
  crashDumpEnabled=RadioCrashDumpGate::available() && candidate.flag(49,false);
  RadioCrashDumpGate::setEnabled(crashDumpEnabled);
  loadBluetoothHistory(); loadWatchOptions();
  Serial.printf("Loaded CRC-verified CasioSync config: SSID=%s, BT TZ=%s, WiFi mode=%s\n",
                ssid,btTimezoneName.c_str(),wifiPowerMode==WIFI_POWER_SCHEDULED?"Scheduled":"Always on");
}


static void clearBluetoothRuntimeHistory(void) {
  btLastSyncEpoch.store(0);
  btLastOutcomeSuccessful.store(false);
  btLastSyncDate = ""; btLastSyncStatus = "Never synced";
  btLastWatchName = ""; btLastWatchAddress = "";
  btFontLastStatus = "No font result retained across reboot";
  btDeliveryEvidence = "No delivery yet";
  btSyncLastYear = btSyncLastYday = -1; btSyncDayComplete = false;
  btConnectionAttempts = btWriteAcknowledgements = 0;
  btNotifications.store(0); btResponseErrors.store(0);
  for (int i=0;i<BT_PROTOCOL_COUNT;++i) {
    btSuccessYear[i] = btSuccessYday[i] = -1;
    btProtocolLastSyncEpoch[i] = 0;
  }
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    btProfileSuccessYear[i] = btProfileSuccessYday[i] = -1;
    btProfileLastSyncEpoch[i] = 0; btProfileLastSyncProtocol[i] = 0;
    btProfileLastSyncAddress[i] = "";
    btBatteryReadings[i] = {};
    btBatteryStatuses[i] = "Not read since boot";
  }
}

static void loadBluetoothHistory(void) {
  clearBluetoothRuntimeHistory();
  btHistorySavedDay = btHistoryAttemptDay = -1;
  btHistorySavedEpoch = 0; btHistorySnapshotGeneration = 0;
  if (!filesystemAvailable) {
    btHistorySaveStatus = "Storage unavailable; Bluetooth history stays in RAM";
    return;
  }
  BtSyncHistory::Snapshot snapshot{};
  File file = LittleFS.open(BT_HISTORY_FILE, "r");
  const bool exists = (bool)file;
  const bool valid = exists && file.size() == sizeof(snapshot) &&
                     file.read(reinterpret_cast<uint8_t *>(&snapshot), sizeof(snapshot)) == sizeof(snapshot) &&
                     BtSyncHistory::valid(snapshot);
  if (file) file.close();
  if (valid) {
    // Read quota metadata even when retention is Off or the generation was
    // invalidated. Toggling/rebooting cannot buy another save on the same day.
    btHistorySavedDay = snapshot.savedDay;
    btHistorySavedEpoch = (uint32_t)snapshot.successEpoch;
    btHistorySnapshotGeneration = snapshot.generation;
  }
  if (!btHistoryPersistEnabled) {
    btHistorySaveStatus = "Off: Bluetooth history stays in RAM only";
    return;
  }
  if (!valid) {
    btHistorySaveStatus = exists ? "Invalid daily snapshot ignored; no startup write" : "No daily snapshot saved yet";
    return;
  }
  if (snapshot.generation != btHistoryGeneration) {
    btHistorySaveStatus = "Previous snapshot disabled; waiting for an eligible successful sync";
    return;
  }
  btLastSyncEpoch.store((uint32_t)snapshot.successEpoch);
  btLastOutcomeSuccessful.store(true);
  struct tm local; bluetoothLocalTime((time_t)snapshot.successEpoch, local);
  char date[24]; strftime(date, sizeof(date), "%Y-%m-%d %H:%M:%S", &local);
  btLastSyncDate = date;
  btLastSyncStatus = String("Watch ") + ((int)snapshot.lastProfile + 1) + ": " +
                     btProtocolName(snapshot.lastProtocol) + " - time write delivered (saved daily snapshot; watch unverified)";
  btDeliveryEvidence = "Saved daily ATT-acknowledged delivery snapshot; watch display unverified";
  btLastWatchAddress = snapshot.profileAddress[snapshot.lastProfile];
  if (btProfileAddress[snapshot.lastProfile].equalsIgnoreCase(btLastWatchAddress.c_str()))
    btLastWatchName = btProfileName[snapshot.lastProfile];
  btConnectionAttempts = snapshot.connections; btWriteAcknowledgements = snapshot.ackedWrites;
  btNotifications.store(snapshot.notifications); btResponseErrors.store(snapshot.responseErrors);
  for (int i=0;i<BT_PROTOCOL_COUNT;++i) {
    btProtocolLastSyncEpoch[i] = snapshot.protocolEpoch[i];
    if (!snapshot.protocolEpoch[i]) continue;
    bluetoothLocalTime((time_t)snapshot.protocolEpoch[i], local);
    btSuccessYear[i] = local.tm_year + 1900; btSuccessYday[i] = local.tm_yday;
  }
  btSyncLastYear = btSuccessYear[BT_PROTOCOL_BX5600_MIP];
  btSyncLastYday = btSuccessYday[BT_PROTOCOL_BX5600_MIP];
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    if (!snapshot.profileEpoch[i] || snapshot.profileProtocol[i] != btProfileProtocol[i] ||
        !btProfileAddress[i].equalsIgnoreCase(snapshot.profileAddress[i])) continue;
    btProfileLastSyncEpoch[i] = snapshot.profileEpoch[i];
    btProfileLastSyncProtocol[i] = snapshot.profileProtocol[i];
    btProfileLastSyncAddress[i] = snapshot.profileAddress[i];
    bluetoothLocalTime((time_t)snapshot.profileEpoch[i], local);
    btProfileSuccessYear[i] = local.tm_year + 1900; btProfileSuccessYday[i] = local.tm_yday;
  }
  btHistorySaveStatus = "First-success daily snapshot restored; later events were RAM only";
}

static bool saveBluetoothHistoryNow(time_t epoch) {
  if (!btHistoryPersistEnabled) {
    btHistorySaveStatus = "Off: Bluetooth history stays in RAM only";
    return false;
  }
  if (!BtSyncHistory::saveDue(true, (int64_t)epoch, btHistorySavedDay, btHistoryAttemptDay)) {
    btHistorySaveStatus = "Daily save limit: subsequent sync results stay in RAM";
    return false;
  }
  btHistoryAttemptDay = BtSyncHistory::brisbaneDay((int64_t)epoch);
  BtSyncHistory::Snapshot snapshot{};
  // Explicit zeroing makes padding deterministic for the bounded binary CRC.
  memset(&snapshot, 0, sizeof(snapshot));
  snapshot.generation = btHistoryGeneration;
  snapshot.savedDay = btHistoryAttemptDay; snapshot.successEpoch = (int64_t)epoch;
  snapshot.lastProfile = btActiveProfile; snapshot.lastProtocol = btActiveProtocol;
  snapshot.connections = btConnectionAttempts; snapshot.ackedWrites = btWriteAcknowledgements;
  snapshot.notifications = btNotifications.load(); snapshot.responseErrors = btResponseErrors.load();
  for (int i=0;i<BT_PROTOCOL_COUNT;++i) snapshot.protocolEpoch[i] = btProtocolLastSyncEpoch[i];
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    if (!btProfileLastSyncEpoch[i] || btProfileLastSyncProtocol[i] != btProfileProtocol[i] ||
        !btProfileAddress[i].equalsIgnoreCase(btProfileLastSyncAddress[i].c_str())) continue;
    snapshot.profileEpoch[i] = btProfileLastSyncEpoch[i];
    snapshot.profileProtocol[i] = btProfileLastSyncProtocol[i];
    strlcpy(snapshot.profileAddress[i], btProfileLastSyncAddress[i].c_str(), sizeof(snapshot.profileAddress[i]));
  }
  BtSyncHistory::seal(snapshot);
  if (!BtSyncHistory::valid(snapshot)) {
    btHistorySaveStatus = "History snapshot invalid; time delivered but no history saved";
    return false;
  }
  File file = LittleFS.open(BT_HISTORY_TEMP_FILE, "w");
  if (!file) { btHistorySaveStatus = "History save failed: temporary file unavailable; no automatic retry"; return false; }
  const size_t written = file.write(reinterpret_cast<const uint8_t *>(&snapshot), sizeof(snapshot));
  file.flush(); file.close();
  File check = LittleFS.open(BT_HISTORY_TEMP_FILE, "r");
  bool verified = written == sizeof(snapshot) && check && check.size() == sizeof(snapshot);
  uint8_t block[64];
  for (size_t offset = 0; verified && offset < sizeof(snapshot);) {
    const size_t remaining = sizeof(snapshot) - offset;
    const size_t count = remaining < sizeof(block) ? remaining : sizeof(block);
    verified = check.read(block, count) == count &&
               memcmp(block, reinterpret_cast<const uint8_t *>(&snapshot) + offset, count) == 0;
    offset += count;
  }
  if (check) check.close();
  if (!verified || !LittleFS.rename(BT_HISTORY_TEMP_FILE, BT_HISTORY_FILE)) {
    btHistorySaveStatus = "History save failed: prior snapshot retained; no automatic retry";
    return false;
  }
  btHistorySavedDay = snapshot.savedDay;
  btHistorySavedEpoch = (uint32_t)epoch;
  btHistorySnapshotGeneration = btHistoryGeneration;
  btHistorySaveStatus = "First successful sync today saved immediately";
  Serial.printf("BT: daily status snapshot saved (%u bytes); later syncs today stay in RAM\n", (unsigned)sizeof(snapshot));
  return true;
}

// UI configuration changes call writeConfigNow() and acknowledge success only
// after atomic flash replacement, so saved settings survive immediate restart.
// Required binding/schedule changes may still use the existing debounce.
// A failed save latches a RAM fault and stops all background retry writes.
// The next explicit successful user save clears that fault.
// V4.13 delivery history bypasses this path: its separate daily snapshot is
// committed immediately, and is never queued for recurring config retries.
// (CONFIG_SAVE_DEBOUNCE_MS/configDirty/configDirtyBecause are declared up
// near the other globals, above loop(), since loop() reads them directly
// and - unlike functions - plain variables/#defines aren't auto-forward-
// declared by the Arduino build system.)

static void loadWatchOptions(void) {
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    btFeatureDesired[i]=CasioWatchFeatures::Desired{};
    btFeatureBoundAddress[i][0]='\0'; btFeatureBoundProtocol[i]=0;
    btFeatureStatus[i]="Off: time synchronization only";
  }
  if (!filesystemAvailable) return;
  CasioWatchOptions::Snapshot snapshot{};
  File file=LittleFS.open(WATCH_OPTIONS_FILE,"r");
  const bool exists=(bool)file;
  const bool valid=exists && file.size()==sizeof(snapshot) &&
      file.read(reinterpret_cast<uint8_t *>(&snapshot),sizeof(snapshot))==sizeof(snapshot) &&
      CasioWatchOptions::valid(snapshot);
  if (file) file.close();
  if (!valid) {
    if (exists) for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i)
      btFeatureStatus[i]="Invalid watch options ignored; defaults Off; no startup write";
    return;
  }
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) {
    const auto &record=snapshot.profiles[i];
    if (record.protocol!=btProfileProtocol[i] ||
        !btProfileAddress[i].equalsIgnoreCase(record.address)) continue;
    btFeatureDesired[i]=CasioWatchOptions::decode(record);
    strlcpy(btFeatureBoundAddress[i],record.address,sizeof(btFeatureBoundAddress[i]));
    btFeatureBoundProtocol[i]=record.protocol;
    btFeatureStatus[i]=btFeatureDesired[i].enabled?"Saved choices; awaiting next watch sync":"Off: time synchronization only";
  }
}

static bool saveWatchOptions(void) {
  if (!filesystemAvailable) return false;
  CasioWatchOptions::Snapshot snapshot{};
  memset(&snapshot,0,sizeof(snapshot));
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i)
    CasioWatchOptions::encode(btFeatureDesired[i],btFeatureBoundAddress[i],btFeatureBoundProtocol[i],snapshot.profiles[i]);
  CasioWatchOptions::seal(snapshot);
  if (!CasioWatchOptions::valid(snapshot)) return false;
  File file=LittleFS.open(WATCH_OPTIONS_TEMP_FILE,"w");
  if (!file) return false;
  const size_t written=file.write(reinterpret_cast<const uint8_t *>(&snapshot),sizeof(snapshot));
  file.flush(); file.close();
  File check=LittleFS.open(WATCH_OPTIONS_TEMP_FILE,"r");
  bool verified=written==sizeof(snapshot) && check && check.size()==sizeof(snapshot);
  uint8_t bytes[64];
  for (size_t offset=0;verified && offset<sizeof(snapshot);) {
    const size_t remaining=sizeof(snapshot)-offset;
    const size_t count=remaining<sizeof(bytes)?remaining:sizeof(bytes);
    verified=check.read(bytes,count)==count &&
             memcmp(bytes,reinterpret_cast<const uint8_t *>(&snapshot)+offset,count)==0;
    offset+=count;
  }
  if (check) check.close();
  return verified && LittleFS.rename(WATCH_OPTIONS_TEMP_FILE,WATCH_OPTIONS_FILE);
}

static bool tempFileMatches(const char *path, const char *expected, size_t length)
{
  File check = LittleFS.open(path, "r");
  if (!check) return false;
  bool valid = check.size() == length;
  uint8_t bytes[64];
  for (size_t offset = 0; valid && offset < length;) {
    const size_t count = (length - offset < sizeof(bytes)) ? length - offset : sizeof(bytes);
    valid = check.read(bytes, count) == count && memcmp(bytes, expected + offset, count) == 0;
    offset += count;
  }
  check.close();
  return valid;
}

static bool configSaveFailed(const char *reason)
{
  configDirty = false;
  configStorageFault = true;
  Serial.printf("Config save failed: %s; previous file retained, automatic retries disabled\n", reason);
  return false;
}

bool writeConfigNow(void) {
  configDirty=false;
  if (!filesystemAvailable) return configSaveFailed("storage unavailable");
  CasioConfigWriter record(storageSerializationBuffer,sizeof(storageSerializationBuffer));
  record.line(CasioConfigFormat::MAGIC);
  record.line(ssid); record.line(passwd); record.line(timezone_name.c_str()); record.number(wifiPowerMode);
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) record.line(btSyncEnabled[i]?"1":"0");
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) record.number(btSyncProtocol[i]);
  record.number(btManualProtocol);
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) record.number(btSyncTimes[i]);
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) record.number(btSyncProfile[i]);
  record.number(btManualProfile);
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) record.line(btProfileAddress[i].c_str());
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) record.line(btProfileName[i].c_str(),true);
  record.line(btAlwaysWaitEnabled?"1":"0");
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) record.number(btProfileProtocol[i]);
  record.line(btTimezoneName.c_str()); record.number(btTimeOffsetMinutes);
  record.line(activityLedEnabled.load()?"1":"0");
  for (int i=0;i<BT_WATCH_PROFILE_COUNT;++i) record.number(btFontMode[i]);
  record.line(btIdlePowerSaveEnabled?"1":"0"); record.line(btHistoryPersistEnabled?"1":"0");
  record.unsignedNumber(btHistoryGeneration);
  record.line(wifiAccessEnabled?"1":"0"); record.number(wifiAccessStart); record.number(wifiAccessEnd);
  record.line(wifiAccessTimezone.c_str()); record.line(crashDumpEnabled?"1":"0");
  if (!record.seal(CasioConfigFormat::FIELD_COUNT)) return configSaveFailed("invalid or oversized complete record");
  CasioConfigRecord candidate;
  const bool valid=candidate.parse(storageSerializationBuffer,record.size()) && validateSavedConfig(candidate);
  candidate.restoreVersionedNewlines();
  if (!valid) return configSaveFailed("invalid configuration fields");
  File file=LittleFS.open(CONFIG_TEMP_FILE,"w");
  if (!file) return configSaveFailed("temporary file unavailable");
  const size_t written=file.write(reinterpret_cast<const uint8_t *>(storageSerializationBuffer),record.size());
  file.flush(); file.close();
  if (written!=record.size() || !tempFileMatches(CONFIG_TEMP_FILE,storageSerializationBuffer,record.size()) ||
      !LittleFS.rename(CONFIG_TEMP_FILE,CONFIG_FILE)) return configSaveFailed("write/readback/rename");
  configStorageFault=false;
  Serial.println("CasioSync config saved atomically");
  return true;
}

void saveConfig(void)
{
  if (configStorageFault) return; // A failed commit never starts a periodic retry loop.
  configDirty = true;
  configDirtyBecause = millis();
}

static void servicePendingConfigSave(void)
{
  if (!configDirty || configStorageFault ||
      (millis() - configDirtyBecause) < CONFIG_SAVE_DEBOUNCE_MS) return;
  configDirty = false;
  writeConfigNow(); // One attempt; failure remains a RAM fault until explicit save.
}

void normalizeBluetoothSlots() {
  // Old configurations may contain overlapping Bluetooth windows. Preserve
  // their stored switches: the scheduler serializes them, and current API
  // validation prevents introducing another overlap during editing.
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) {
    for (int j=0;j<i;++j) if (btSyncEnabled[j] &&
        btSyncEnabled[i] &&
        btCircularDistance(btSyncTimes[i],btSyncTimes[j]) <= BT_PREPARE_MINUTES+BT_WINDOW_AFTER_MINUTES+1)
      Serial.printf("BT: stored slots %d and %d overlap; enabled settings retained\n", j+1, i+1);
  }
}
// Wake before every enabled Bluetooth occurrence in its own watch timezone.
// Adaptive clock-trust wakes also operate when no automatic slot is enabled.
static bool shouldWifiBeOnForBtSchedule(void) {
  if (!clockTrusted()) return false;
  const time_t epoch = time(nullptr);
  struct tm local; bluetoothLocalTime(epoch, local);
  const int minute = btMinutesOfDay(local);
  constexpr int lead = 10;
  for (int i=0;i<BT_SYNC_SLOT_COUNT;++i) {
    if (!btSyncEnabled[i]) continue;
    const int start = (btSyncTimes[i] - lead + 1440) % 1440;
    const int elapsed = (minute - start + 1440) % 1440;
    if (elapsed <= lead + BT_WINDOW_AFTER_MINUTES) return true;
  }
  return false;
}

// Independent web-access civil time; never changes the global TZ or applies
// the Bluetooth watch offset.
static bool wifiAccessWindowOpen(void) {
  if (!wifiAccessEnabled) return false;
  time_t epoch = time(nullptr);
  if ((int64_t)epoch < 1577836800) return false;
  struct tm utc, local;
  gmtime_r(&epoch, &utc);
  const int offset = btBaseOffsetSeconds(wifiAccessTimezone) +
                     (btDstAtUtc(wifiAccessTimezone, utc) ? 3600 : 0);
  time_t adjusted = epoch + offset;
  gmtime_r(&adjusted, &local);
  return CasioWifiAccessWindow::containsMinute(local.tm_hour * 60 + local.tm_min,
                                              wifiAccessStart, wifiAccessEnd);
}

// Called from loop() every few seconds when wifiPowerMode == WIFI_POWER_SCHEDULED.
// Turns the WiFi radio fully on/off to match shouldWifiBeOnForBtSchedule(),
// with a mandatory on-window for the first WIFI_BOOT_ON_DURATION_MS after
// boot so the device is always reachable to be configured. Never runs while
// in AP configuration mode.
static bool wifiClockSyncWindowOpen(void)
{
  const uint64_t nowMs = (uint64_t)esp_timer_get_time() / 1000ULL;
  portENTER_CRITICAL(&clockMux);
  const uint32_t completed = clockNtpSyncCount;
  const bool rejected = clockNtpRejected;
  portEXIT_CRITICAL(&clockMux);
  if (wifiClockWakeActive) {
    if (completed != wifiClockWakeSyncCount && !rejected) {
      wifiClockWakeActive = false;
      wifiClockRetryAtMs = 0;
      wifiClockRetryDelayMs = 30000;
    } else if (nowMs - wifiClockWakeStartedMs >= WIFI_CLOCK_WAKE_TIMEOUT_MS) {
      wifiClockWakeActive = false;
      wifiClockRetryAtMs = nowMs + wifiClockRetryDelayMs;
      wifiClockRetryDelayMs = wifiClockRetryDelayMs < WIFI_RETRY_MAX_MS / 2
          ? wifiClockRetryDelayMs * 2 : WIFI_RETRY_MAX_MS;
    } else return true;
  }
  const uint32_t age = clockAgeSeconds();
  const uint32_t interval = ntpIntervalSec.load();
  const uint32_t wakeAge = interval > WIFI_CLOCK_WAKE_LEAD_SEC
      ? interval - WIFI_CLOCK_WAKE_LEAD_SEC : 0;
  if ((rejected || age == UINT32_MAX || age >= wakeAge) && nowMs >= wifiClockRetryAtMs) {
    wifiClockWakeActive = true;
    wifiClockWakeStartedMs = nowMs;
    wifiClockWakeSyncCount = completed;
    return true;
  }
  return false;
}

void updateWifiPowerManagement(void)
{
  const unsigned long now = millis();
  if (!wifiBootAccessComplete && now - bootMillis >= WIFI_BOOT_ON_DURATION_MS)
    wifiBootAccessComplete = true;
  static int appliedPowerMode = -1;
  if (WiFi.getMode() != WIFI_OFF && appliedPowerMode != wifiPowerMode) {
    if (WiFi.setSleep(wifiPowerMode != WIFI_POWER_ALWAYS_ON)) appliedPowerMode = wifiPowerMode;
  }
  if (ap_mode || !filesystemAvailable) return; // Setup/fault AP remains available.
  if (wifiConnectionPending) return; // A bounded association owns this wake.
  if (wifiPowerMode != WIFI_POWER_SCHEDULED) {
    if (!wifiRadioEnabled) { wifiRadioEnabled=true; ntpstart(); }
    if (WiFi.getMode() != WIFI_OFF) wifiPowerFault = false;
    return;
  }
  static unsigned long lastCheck = 0;
  if (now - lastCheck < 1000) return;
  lastCheck = now;
  if (wifiRecoveryWindowActive && now - wifiRecoveryStarted >= WIFI_BOOT_ON_DURATION_MS)
    wifiRecoveryWindowActive = false;
  const bool clockWake = wifiClockSyncWindowOpen();
  const bool wantOn = !wifiBootAccessComplete || wifiRecoveryWindowActive ||
      wifiAccessWindowOpen() || shouldWifiBeOnForBtSchedule() || clockWake;
  if (wantOn && !wifiRadioEnabled) {
    Serial.println("WiFi power-save: waking radio for sync or web-access window");
    wifiRadioEnabled = true;
    ntpstart();
  } else if (!wantOn && (wifiRadioEnabled || wifiPowerShutdownPending || WiFi.getMode() != WIFI_OFF)) {
    if (wifiRadioEnabled)
      Serial.println("WiFi power-save: sync/web-access windows closed, powering down radio");
    wifiRadioEnabled = false;
    (void)ntpstop();
  }
}

void checkWiFiConnection(void)
{
  const uint64_t nowMs = (uint64_t)esp_timer_get_time() / 1000ULL;
  if (!filesystemAvailable || strlen(ssid) == 0) {
    if (!ap_mode) startAPMode();
    return;
  }
  if (wifiPowerMode == WIFI_POWER_SCHEDULED && !wifiRadioEnabled && !ap_mode) {
    // Desired Off is separate from observed mode. Keep a surviving station
    // usable while the power manager retries its checked shutdown.
    if (wifiPowerShutdownPending && WiFi.status() == WL_CONNECTED) {
      if (!webServerStarted) initWebServer();
      if (!esp_sntp_enabled() && nowMs >= wifiNtpConfigureRetryAtMs) {
        if (configureNtpClient()) {
          wifiNtpConfigureRetryAtMs = 0;
          wifiNtpConfigureRetryDelayMs = 5000;
        } else {
          wifiNtpConfigureRetryAtMs = nowMs + wifiNtpConfigureRetryDelayMs;
          wifiNtpConfigureRetryDelayMs = wifiNtpConfigureRetryDelayMs < WIFI_RETRY_MAX_MS / 2
              ? wifiNtpConfigureRetryDelayMs * 2 : WIFI_RETRY_MAX_MS;
        }
      }
    }
    return;
  }
  if (WiFi.status() == WL_CONNECTED) {
    // Retain AP until STA association succeeds. Clock trust remains guarded
    // separately, so recovery never writes an untrusted watch time.
    if (wifiRadioEnabled) wifiPowerFault = false;
    if (ap_mode && !stopAPMode()) return;
    if (!webServerStarted) initWebServer();
    if (wifiConnectionPending) {
      // Association is complete even if SNTP initialization fails. Keeping
      // this pending forever would defeat the finite power-save wake budget.
      wifiConnectionPending = false;
      if (wifiConnectionAccessGrace) {
        wifiRecoveryStarted = millis();
        wifiRecoveryWindowActive = true;
      }
      Serial.printf("WiFi connected! Web server at http://%s\n", WiFi.localIP().toString().c_str());
    }
    wifi_connect_start = 0;
    wifiStaRetryAtMs = 0;
    wifiStaRetryDelayMs = 30000;
    if (!esp_sntp_enabled()) {
      if (nowMs < wifiNtpConfigureRetryAtMs) return;
      if (!configureNtpClient()) {
        wifiNtpConfigureRetryAtMs = nowMs + wifiNtpConfigureRetryDelayMs;
        wifiNtpConfigureRetryDelayMs = wifiNtpConfigureRetryDelayMs < WIFI_RETRY_MAX_MS / 2
            ? wifiNtpConfigureRetryDelayMs * 2 : WIFI_RETRY_MAX_MS;
        return;
      }
      wifiNtpConfigureRetryAtMs = 0;
      wifiNtpConfigureRetryDelayMs = 5000;
    }
    return;
  }
  if (wifiConnectionPending) {
    if (millis() - wifi_connect_start < WIFI_CONNECT_TIMEOUT) return;
    Serial.println("WiFi connection timeout; retaining setup AP with automatic station retries");
    startAPMode();
    wifiStaRetryAtMs = nowMs + wifiStaRetryDelayMs;
    wifiStaRetryDelayMs = wifiStaRetryDelayMs < WIFI_RETRY_MAX_MS / 2
        ? wifiStaRetryDelayMs * 2 : WIFI_RETRY_MAX_MS;
    return;
  }
  if (apStartPending || nowMs < wifiStaRetryAtMs) return;
  // A single association attempt has its own deadline. Calling reconnect
  // every poll would continuously interrupt association. AP+STA retains the
  // working setup network throughout retries after a router outage.
  if (ap_mode) beginWifiCredentialConnection();
  else {
    if (esp_sntp_enabled()) esp_sntp_stop();
    wifiConnectionPending = true;
    wifiConnectionAccessGrace = true;
    wifi_connect_start = millis();
    Serial.println("WiFi connection lost; starting bounded station recovery");
    WiFi.reconnect();
  }
}

void startAPMode(void)
{
  ap_mode = true;
  wifiConnectionPending = false;
  wifi_connect_start = 0;
  wifiRadioEnabled = true;
  wifiPowerShutdownPending = false;
  wifiPowerRetryAtMs = 0;
  wifiPowerRetryDelayMs = 1000;
  apStartPending = true;
  apStartAttemptMillis = millis();
  // Stopping an unstarted client can post to an uninitialized TCP/IP mailbox.
  if (esp_sntp_enabled()) esp_sntp_stop();
  if (webServerStarted) { server.stop(); webServerStarted=false; }
  // The netif MAC can still be all-zero until the asynchronous AP_START
  // event runs. Read the device's derived AP MAC independently of that event.
  uint8_t mac[6] = {};
  char ap_name[32];
  if (esp_read_mac(mac, ESP_MAC_WIFI_SOFTAP) == ESP_OK && !(mac[0] & 1) &&
      (mac[0] || mac[1] || mac[2] || mac[3] || mac[4] || mac[5])) {
    snprintf(ap_name, sizeof(ap_name), "%s_%02X%02X%02X",
             DEVICENAME_PREFIX, mac[3], mac[4], mac[5]);
  } else {
    snprintf(ap_name, sizeof(ap_name), "%s_Setup", DEVICENAME_PREFIX);
    Serial.println("AP device MAC unavailable; using CasioSync_Setup fallback");
  }
  if (!WiFi.mode(WIFI_AP)) {
    Serial.println("ERROR: AP WiFi driver startup failed; retry in 5 seconds");
    return;
  }
  // softAP waits for AP_START before configuring credentials. Explicitly
  // advertise on 2.4 GHz channel 1; do not claim success on an SDK error.
  if (!WiFi.softAP(ap_name, "12345678", 1, 0, 4) || !WiFi.AP.started()) {
    Serial.println("ERROR: AP start/configuration failed; retry in 5 seconds");
    return;
  }

  IPAddress IP = WiFi.softAPIP();
  if (uint32_t(IP) == 0) {
    Serial.println("ERROR: AP has no local IP; retry in 5 seconds");
    return;
  }
  apStartPending = false;
  wifiPowerFault = false; // A verified setup AP satisfies the new desired On state.
  Serial.printf("AP Mode started. SSID: %s, IP: %s\n", ap_name, IP.toString().c_str());

  initWebServer();
  Serial.println("Web server started");
}

void serviceAPStartup(void)
{
  if (!ap_mode || !apStartPending || wifiConnectionPending ||
      millis() - apStartAttemptMillis < AP_START_RETRY_MS) return;
  apStartAttemptMillis = millis();
  // Reset a failed/partial driver start so the next attempt gets a new
  // AP_START event. A healthy AP never enters this recovery path.
  if (!WiFi.mode(WIFI_OFF)) {
    Serial.println("ERROR: AP retry could not stop WiFi; retry in 5 seconds");
    return;
  }
  Serial.println("Retrying configuration AP startup");
  startAPMode();
}

bool stopAPMode(void)
{
  if (!WiFi.softAPdisconnect(true) || !WiFi.mode(WIFI_STA)) {
    Serial.println("AP mode transition failed; restoring configuration AP");
    startAPMode(); // AP.clear() may already have removed its credentials/interface.
    return false;
  }
  ap_mode = false;
  apStartPending = false;
  if (webServerStarted) { server.stop(); webServerStarted=false; }
  // Resume STA mode web server after connecting to Wi-Fi.
  WiFi.setSleep(wifiPowerMode != WIFI_POWER_ALWAYS_ON);
  Serial.println("AP mode stopped, web server continues on WiFi");
  return true;
}

static void beginWifiCredentialConnection(void)
{
  wifiRadioEnabled = true;
  wifiPowerShutdownPending = false;
  wifiPowerRetryAtMs = 0;
  wifiPowerRetryDelayMs = 1000;
  ntpsync = 0; // Clock holdover trust is independent of a fresh network reply.
  // Stopping an unstarted client can post to an uninitialized TCP/IP mailbox.
  if (esp_sntp_enabled()) esp_sntp_stop();
  if (strlen(ssid) == 0) { startAPMode(); return; }
  // Keep the configuration AP accessible until station association succeeds.
  if (!WiFi.mode(ap_mode ? WIFI_AP_STA : WIFI_STA)) {
    Serial.println("Could not start WiFi credential connection; restoring AP");
    startAPMode();
    wifiStaRetryAtMs = (uint64_t)esp_timer_get_time() / 1000ULL + wifiStaRetryDelayMs;
    wifiStaRetryDelayMs = wifiStaRetryDelayMs < WIFI_RETRY_MAX_MS / 2
        ? wifiStaRetryDelayMs * 2 : WIFI_RETRY_MAX_MS;
    return;
  }
  wifiPowerFault = false; // The driver acknowledged the desired powered-on mode.
  WiFi.setSleep(wifiPowerMode != WIFI_POWER_ALWAYS_ON);
  wifiConnectionPending = true;
  wifiConnectionAccessGrace = true;
  wifiNtpConfigureRetryAtMs = 0;
  wifiNtpConfigureRetryDelayMs = 5000;
  apStartPending = false;
  wifi_connect_start = millis();
  WiFi.begin(ssid, passwd);
  Serial.printf("Connecting to WiFi: %s (configuration AP retained until connected)\n", ssid);
}

static String bluetoothHistorySavedAt(void) {
  if (!btHistoryPersistEnabled || !btHistorySavedEpoch ||
      btHistorySnapshotGeneration != btHistoryGeneration) return "";
  struct tm local; bluetoothLocalTime((time_t)btHistorySavedEpoch, local);
  char date[24]; strftime(date, sizeof(date), "%Y-%m-%d %H:%M:%S", &local);
  return String(date);
}


static bool bluetoothSettingsMutable(void) {
  if (btBleBusy || btPairModeActive || btPairRequested) return false;
  // Manual selection controls the next explicit/passive window. An automatic
  // slot already has its own active profile/protocol and must keep listening.
  if (btWindowActive && btSyncActiveSlot < 0) stopBluetoothWindow();
  btManualSyncRequested = false;
  return true;
}

static bool bluetoothSlotSettingsMutable(void) {
  // Validation must not cancel a window before the remaining checks succeed.
  return !btBleBusy && !btPairModeActive && !btPairRequested;
}

static const char* bluetoothStateText(void) {
  if (btShutdownRequested.load()) return "Bluetooth recovery pending";
  if (btBleBusy) return btPhase;
  if (btPairRequested || btPairModeActive) return "Pairing";
  if (btManualSyncRequested) return "Waiting for watch";
  if (btWindowActive && btSyncActiveSlot >= 0) return "Automatic sync window active";
  if (btWindowActive) return btScan && btScan->isScanning() ? "Scanning" : "Waiting for watch";
  if (btAlwaysWaitEnabled && btProfileAddress[btManualProfile].length() != 17) return "No watch paired";
  return btPhase;
}

// Shared bounded response storage is used only by the single HTTP loop task.
// Send its bytes directly; WebServer's const-char send overload creates a String.
static char apiResponseBuffer[8192];
static void sendBoundedJson(CasioJsonWriter& json, int code = 200) {
  if (!json.ok()) {
    server.send(503, "application/json", "{\"status\":\"error\",\"message\":\"Response capacity exceeded\"}");
    return;
  }
  server.setContentLength(json.size());
  server.send(code, "application/json", String());
  server.sendContent(json.data(), json.size());
}

static CasioWatchFeatures::Caps profileFeatureCapabilities(int profile) {
  if (profile<0 || profile>=BT_WATCH_PROFILE_COUNT || btProfileAddress[profile].length()!=17)
    return CasioWatchFeatures::Caps{};
  return CasioWatchFeatures::capabilities(btProfileName[profile].c_str(),btProfileName[profile].length());
}
static void appendFeatureDesired(CasioJsonWriter &json,const CasioWatchFeatures::Desired &d) {
  json.append("{\"enabled\":").boolean(d.enabled);
  json.key("alarms_enabled").boolean(d.alarmsEnabled);
  json.key("alarms").append("[");
  for (size_t i=0;i<CasioWatchFeatures::kAlarmCount;++i) {
    if (i) json.append(",");
    json.append("{\"enabled\":").boolean(d.alarms[i].enabled);
    json.key("hour").number(d.alarms[i].hour);
    json.key("minute").number(d.alarms[i].minute).append("}");
  }
  json.append("]");
  json.key("hourly_chime").number(d.hourlyChime);
  json.key("timer_enabled").boolean(d.timerEnabled); json.key("timer_seconds").number(d.timerSeconds);
  json.key("basic_mask").number(d.basicMask); json.key("time_format_24").boolean(d.timeFormat24);
  json.key("button_tone").boolean(d.buttonTone); json.key("auto_light").boolean(d.autoLight);
  json.key("power_saving").boolean(d.powerSaving); json.key("long_light").boolean(d.longLight);
  json.key("date_day_first").boolean(d.dateDayFirst); json.key("language").number(d.language);
  json.key("auto_adjust_enabled").boolean(d.autoAdjustEnabled); json.key("auto_adjust").boolean(d.autoAdjust);
  json.key("auto_adjust_minute").number(d.autoAdjustMinute).append("}");
}

static void appendBluetoothProfiles(CasioJsonWriter& json) {
  json.key("bt_profiles").append("[");
  for (int i = 0; i < BT_WATCH_PROFILE_COUNT; ++i) {
    if (i) json.append(",");
    json.append("{\"id\":").number(i);
    json.key("bound").boolean(btProfileAddress[i].length() == 17);
    json.key("name").quoted(btProfileName[i].c_str());
    json.key("address").quoted(btProfileAddress[i].c_str());
    json.key("protocol").number(btProfileProtocol[i]);
    json.key("font_mode").number(static_cast<int>(btFontMode[i]));
    json.key("done_today").boolean(btProfileDoneToday(i));
    const auto& battery = btBatteryReadings[i];
    const bool available = btProfileProtocol[i] == BT_PROTOCOL_BX5600_MIP &&
                           battery.matches(btProfileAddress[i].c_str());
    json.key("battery_percent");
    if (available) json.number(battery.percent); else json.append("null");
    char readAt[24] = "";
    if (available) {
      struct tm local; bluetoothLocalTime(battery.sampledUtc, local);
      strftime(readAt, sizeof(readAt), "%Y-%m-%d %H:%M:%S", &local);
    }
    json.key("battery_read_at").quoted(readAt);
    const char* status = btProfileAddress[i].length() != 17
      ? "Pair a GW-BX5600 to read its battery"
      : btProfileProtocol[i] != BT_PROTOCOL_BX5600_MIP
        ? "Unavailable: selected protocol has no validated battery reading"
        : btBatteryStatuses[i];
    json.key("battery_status").quoted(status);
    const auto caps=profileFeatureCapabilities(i);
    json.key("feature_desired"); appendFeatureDesired(json,btFeatureDesired[i]);
    json.key("feature_capabilities").append("{\"basic_mask\":").number(caps.basicMask);
    json.key("alarms").boolean(caps.alarmCount>0); json.key("alarm_count").number(caps.alarmCount);
    json.key("hourly_chime").boolean(caps.hourlyChime); json.key("timer").boolean(caps.timer);
    json.key("timer_max_seconds").number(caps.timerMaxSeconds); json.key("auto_adjust").boolean(caps.autoAdjust).append("}");
    json.key("feature_status").quoted(btFeatureStatus[i]).append("}");
  }
  json.append("]");
}

static void appendRecentBluetoothSyncs(CasioJsonWriter& json) {
  const int profile = btManualProfile;
  const bool valid = profile >= 0 && profile < BT_WATCH_PROFILE_COUNT;
  json.key("bt_recent_sync_profile").number(valid ? profile : -1);
  json.key("bt_recent_syncs").append("[");
  if (valid) {
    // The HTTP and sync-result paths share loopTask ownership. Reconcile a
    // changed/removed binding before exposing any old watch's RAM history.
    btRecentSyncs.bind(profile, btProfileAddress[profile].c_str(), btProfileProtocol[profile]);
    const size_t count = btRecentSyncs.count(profile);
    for (size_t i = 0; i < count; ++i) {
      const auto* entry = btRecentSyncs.latest(profile, i);
      if (!entry) break;
      if (i) json.append(",");
      char date[24] = "";
      if (entry->utcEpoch) {
        struct tm local;
        bluetoothLocalTime(static_cast<time_t>(entry->utcEpoch), local);
        strftime(date, sizeof(date), "%Y-%m-%d %H:%M:%S", &local);
      }
      json.append("{\"utc_epoch\":").number(entry->utcEpoch);
      json.key("date").quoted(date);
      json.key("protocol").number(entry->protocol);
      json.key("successful").boolean(entry->successful).append("}");
    }
  }
  json.append("]");
}

static void appendCommonSettings(CasioJsonWriter& json) {
  json.key("timezone").quoted(timezone_name.c_str());
  json.key("bt_timezone").quoted(btTimezoneName.c_str());
  json.key("bt_time_offset_minutes").number(btTimeOffsetMinutes);
  json.key("wifi_power_mode").number(wifiPowerMode);
  json.key("bt_day_complete").boolean(btSyncDayComplete);
  json.key("bt_manual_protocol").number(btManualProtocol);
  json.key("bt_manual_profile").number(btManualProfile);
  json.key("bt_active_protocol").number(btActiveProtocol);
  json.key("bt_active_profile").number(btActiveProfile);
  json.key("bt_last_sync_status").quoted(btLastSyncStatus.c_str());
  json.key("bt_last_sync_date").quoted(btLastSyncDate.c_str());
  json.key("bt_always_wait").boolean(btAlwaysWaitEnabled);
  json.key("activity_led_enabled").boolean(activityLedEnabled.load());
  json.key("bt_idle_power_save").boolean(btIdlePowerSaveEnabled);
  json.key("bt_font_status").quoted(btFontLastStatus.c_str());
  json.key("bt_state").quoted(bluetoothStateText());
  json.key("bt_pairing").boolean(btPairModeActive || btPairRequested);
  json.key("bt_history_persist").boolean(btHistoryPersistEnabled);
  char savedAt[24] = "";
  if (btHistoryPersistEnabled && btHistorySavedEpoch && btHistorySnapshotGeneration == btHistoryGeneration) {
    struct tm local; bluetoothLocalTime(static_cast<time_t>(btHistorySavedEpoch), local);
    strftime(savedAt, sizeof(savedAt), "%Y-%m-%d %H:%M:%S", &local);
  }
  json.key("bt_history_saved_at").quoted(savedAt);
  json.key("bt_history_save_status").quoted(btHistorySaveStatus.c_str());
  json.key("bt_last_sync_epoch").number(btLastSyncEpoch.load());
  json.key("bt_last_outcome_successful").boolean(btLastOutcomeSuccessful.load());
  json.key("wifi_access_enabled").boolean(wifiAccessEnabled);
  json.key("wifi_access_start").number(wifiAccessStart);
  json.key("wifi_access_end").number(wifiAccessEnd);
  json.key("wifi_access_timezone").quoted(wifiAccessTimezone.c_str());
  json.key("wifi_access_active").boolean(wifiAccessWindowOpen());
  json.key("crash_dump_enabled").boolean(crashDumpEnabled);
  json.key("crash_dump_available").boolean(RadioCrashDumpGate::available());
  json.key("filesystem_available").boolean(filesystemAvailable);
  json.key("config_storage_fault").boolean(configStorageFault);
  json.key("firmware_version").quoted(FIRMWARE_VERSION);
  json.key("firmware_build").quoted(FIRMWARE_BUILD);
  appendBluetoothProfiles(json);
  appendRecentBluetoothSyncs(json);
  json.key("bt_times").append("[");
  for (int i = 0; i < BT_SYNC_SLOT_COUNT; ++i) {
    if (i) json.append(",");
    json.append("{\"minute\":").number(btSyncTimes[i]);
    json.key("enabled").boolean(btSyncEnabled[i]);
    json.key("protocol").number(btSyncProtocol[i]);
    json.key("profile").number(btSyncProfile[i]);
    json.key("done_today").boolean(btProfileDoneToday(btSyncProfile[i]));
    json.key("conflict").boolean(btOverlapsOtherEnabledSlot(i, btSyncTimes[i]));
    json.append("}");
  }
  json.append("]");
}

void initWebServer(void)
{
  if (webServerStarted) return;
  if (!webRoutesRegistered) {
  // Register routes only once. Restart listening after Wi-Fi sleep/AP switch.
  // Serve index page
  server.on("/", HTTP_GET, []() {
    sendIndexPage();
  });

  // A mount error never authorizes automatic formatting. Recovery is possible
  // only through the setup AP after the user explicitly confirms data loss.
  server.on("/api/storage/reset", HTTP_POST, []() {
    if (filesystemAvailable || !ap_mode) {
      server.send(409, "application/json", "{\"status\":\"error\",\"message\":\"Storage reset is restricted to a filesystem-fault setup AP\"}"); return;
    }
    if (!server.hasArg("confirm") || server.arg("confirm") != "ERASE_SAVED_SETTINGS") {
      server.send(400, "application/json", "{\"status\":\"error\",\"message\":\"Explicit confirmation of saved-settings erasure is required\"}"); return;
    }
    if (!LittleFS.format()) {
      server.send(500, "application/json", "{\"status\":\"error\",\"message\":\"Storage recovery failed; setup AP remains available\"}"); return;
    }
    server.send(200, "application/json", "{\"status\":\"ok\",\"message\":\"Saved settings erased; restarting into setup AP\"}");
    delay(200);
    ESP.restart();
  });

  server.on("/api/watch-settings",HTTP_POST,[]() {
    if (btBleBusy || btPairModeActive || btPairRequested) {
      server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Watch transaction or pairing active; retry when it finishes\"}"); return;
    }
    if (!server.hasArg("plain")) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Complete watch settings JSON required\"}"); return;
    }
    String body;
    if (!server.checkedArg("plain",body) || body.length()>2048) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Watch settings payload unavailable or too large\"}"); return;
    }
    static StaticJsonDocument<3072> document; // HTTP handlers share one loopTask.
    document.clear();
    if (deserializeJson(document,body) || !document.is<JsonObject>() || document.overflowed()) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid watch settings JSON\"}"); return;
    }
    const JsonObjectConst object=document.as<JsonObjectConst>();
    auto integer=[&object](const char *key,int32_t lo,int32_t hi,int32_t &result) {
      const JsonVariantConst value=object[key];
      if (!value.is<int32_t>()) return false;
      result=value.as<int32_t>(); return result>=lo && result<=hi;
    };
    auto flag=[&object](const char *key,bool &result) {
      const JsonVariantConst value=object[key];
      if (!value.is<bool>()) return false;
      result=value.as<bool>(); return true;
    };
    CasioWatchFeatures::Desired desired{};
    int32_t profile, chime, timerSeconds, mask, language, adjustMinute;
    bool valid=integer("profile",0,BT_WATCH_PROFILE_COUNT-1,profile) &&
      flag("enabled",desired.enabled) && flag("alarms_enabled",desired.alarmsEnabled) &&
      integer("hourly_chime",-1,1,chime) && flag("timer_enabled",desired.timerEnabled) &&
      integer("timer_seconds",1,86400,timerSeconds) && integer("basic_mask",0,127,mask) &&
      flag("time_format_24",desired.timeFormat24) && flag("button_tone",desired.buttonTone) &&
      flag("auto_light",desired.autoLight) && flag("power_saving",desired.powerSaving) &&
      flag("long_light",desired.longLight) && flag("date_day_first",desired.dateDayFirst) &&
      integer("language",0,5,language) && flag("auto_adjust_enabled",desired.autoAdjustEnabled) &&
      flag("auto_adjust",desired.autoAdjust) && integer("auto_adjust_minute",0,59,adjustMinute);
    const JsonArrayConst alarms=object["alarms"].as<JsonArrayConst>();
    valid=valid && alarms.size()==CasioWatchFeatures::kAlarmCount;
    for (size_t i=0;valid && i<CasioWatchFeatures::kAlarmCount;++i) {
      const JsonObjectConst alarm=alarms[i].as<JsonObjectConst>();
      valid=!alarm.isNull() && alarm["enabled"].is<bool>() && alarm["hour"].is<int>() && alarm["minute"].is<int>();
      if (!valid) break;
      const int hour=alarm["hour"].as<int>(), minute=alarm["minute"].as<int>();
      valid=hour>=0 && hour<=23 && minute>=0 && minute<=59;
      if (valid) desired.alarms[i]={alarm["enabled"].as<bool>(),static_cast<uint8_t>(hour),static_cast<uint8_t>(minute)};
    }
    if (!valid) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid or incomplete watch options; no settings changed\"}"); return;
    }
    desired.hourlyChime=chime; desired.timerSeconds=timerSeconds; desired.basicMask=mask;
    desired.language=language; desired.autoAdjustMinute=adjustMinute;
    const auto caps=profileFeatureCapabilities(profile);
    if (desired.enabled && (btProfileAddress[profile].length()!=17 ||
        (desired.alarmsEnabled && !caps.alarmCount) || (desired.hourlyChime>=0 && !caps.hourlyChime) ||
        (desired.timerEnabled && (!caps.timer || desired.timerSeconds>caps.timerMaxSeconds)) ||
        (desired.basicMask & ~caps.basicMask) || (desired.autoAdjustEnabled && !caps.autoAdjust))) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Pair a supported watch and choose only its available features\"}"); return;
    }
    const auto previous=btFeatureDesired[profile];
    char previousAddress[18]; memcpy(previousAddress,btFeatureBoundAddress[profile],sizeof(previousAddress));
    const uint8_t previousProtocol=btFeatureBoundProtocol[profile];
    btFeatureDesired[profile]=desired;
    strlcpy(btFeatureBoundAddress[profile],btProfileAddress[profile].c_str(),sizeof(btFeatureBoundAddress[profile]));
    btFeatureBoundProtocol[profile]=btProfileProtocol[profile];
    if (!saveWatchOptions()) {
      btFeatureDesired[profile]=previous;
      memcpy(btFeatureBoundAddress[profile],previousAddress,sizeof(previousAddress));
      btFeatureBoundProtocol[profile]=previousProtocol;
      server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Watch options were not saved; previous choices retained\"}"); return;
    }
    btFeatureStatus[profile]=desired.enabled?"Choices saved; apply and verify during next watch sync":"Off: time synchronization only";
    server.send(200,"application/json","{\"status\":\"ok\"}");
  });

  // API endpoints
  server.on("/api/config", HTTP_GET, []() {
    CasioJsonWriter json(apiResponseBuffer, sizeof(apiResponseBuffer));
    json.append("{\"ssid\":").quoted(ssid);
    appendCommonSettings(json);
    json.append("}");
    sendBoundedJson(json);
  });

  server.on("/api/config", HTTP_POST, []() {
    if (server.hasArg("crash_dump_enabled")) {
      String value = server.arg("crash_dump_enabled");
      if (value != "0" && value != "1" && value != "true" && value != "false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid crash-dump setting\"}"); return;
      }
      const bool enabled = value == "1" || value == "true";
      if (enabled && !RadioCrashDumpGate::available()) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Crash-dump storage unavailable in this ESP32 core\"}"); return;
      }
      const bool previousEnabled = crashDumpEnabled;
      crashDumpEnabled = enabled;
      if (!writeConfigNow()) {
        crashDumpEnabled = previousEnabled; saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Crash-dump setting could not be saved; previous value retained\"}"); return;
      }
      RadioCrashDumpGate::setEnabled(crashDumpEnabled);
      server.send(200,"application/json","{\"status\":\"ok\"}"); return;
    }
    if (server.hasArg("bt_history_persist")) {
      String value = server.arg("bt_history_persist");
      if (value != "0" && value != "1" && value != "true" && value != "false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Bluetooth history retention value\"}"); return;
      }
      const bool previousEnabled = btHistoryPersistEnabled;
      const uint32_t previousGeneration = btHistoryGeneration;
      const bool enabled = value == "1" || value == "true";
      if (!enabled && previousEnabled && btHistoryGeneration == UINT32_MAX) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"History generation exhausted; setting retained\"}"); return;
      }
      btHistoryPersistEnabled = enabled;
      // A disabled snapshot must never reappear after Off -> On -> reboot.
      // Config stores this invalidation; no history write/delete is needed.
      if (!enabled && previousEnabled) ++btHistoryGeneration;
      if (!writeConfigNow()) {
        btHistoryPersistEnabled = previousEnabled; btHistoryGeneration = previousGeneration;
        saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"History retention could not be saved; previous value retained\"}"); return;
      }
      btHistorySaveStatus = enabled ? "On: next eligible first-success snapshot will be saved"
                                   : "Off: Bluetooth history stays in RAM only";
      server.send(200,"application/json","{\"status\":\"ok\"}"); return;
    }
    if (server.hasArg("wifi_access_enabled") || server.hasArg("wifi_access_start") ||
        server.hasArg("wifi_access_end") || server.hasArg("wifi_access_timezone")) {
      if (!server.hasArg("wifi_access_enabled") || !server.hasArg("wifi_access_start") ||
          !server.hasArg("wifi_access_end") || !server.hasArg("wifi_access_timezone")) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Complete daily Wi-Fi schedule required\"}"); return;
      }
      String value = server.arg("wifi_access_enabled");
      int start = server.arg("wifi_access_start").toInt();
      int end = server.arg("wifi_access_end").toInt();
      String zone = server.arg("wifi_access_timezone");
      if ((value != "0" && value != "1" && value != "true" && value != "false") ||
          server.arg("wifi_access_start") != String(start) || server.arg("wifi_access_end") != String(end) ||
          !CasioWifiAccessWindow::validMinutes(start, end) || !validTimezoneName(zone)) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid daily Wi-Fi schedule; start and end must differ\"}"); return;
      }
      const bool previousEnabled = wifiAccessEnabled;
      const int previousStart = wifiAccessStart, previousEnd = wifiAccessEnd, previousMode = wifiPowerMode;
      char previousZone[32];
      if (wifiAccessTimezone.length() >= sizeof(previousZone)) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Wi-Fi access timezone unavailable; settings retained\"}"); return;
      }
      strlcpy(previousZone,wifiAccessTimezone.c_str(),sizeof(previousZone));
      const size_t reserveLength=wifiAccessTimezone.length()>zone.length()?wifiAccessTimezone.length():zone.length();
      if (!wifiAccessTimezone.reserve(reserveLength)) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Not enough memory to save Wi-Fi access timezone; settings retained\"}"); return;
      }
      wifiAccessEnabled = value == "1" || value == "true";
      wifiAccessStart = start; wifiAccessEnd = end; wifiAccessTimezone = zone;
      if (wifiAccessEnabled) wifiPowerMode = WIFI_POWER_SCHEDULED;
      if (!writeConfigNow()) {
        wifiAccessEnabled = previousEnabled; wifiAccessStart = previousStart; wifiAccessEnd = previousEnd;
        wifiAccessTimezone = previousZone; wifiPowerMode = previousMode;
        saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Wi-Fi schedule could not be saved; previous settings retained\"}"); return;
      }
      server.send(200,"application/json","{\"status\":\"ok\"}"); return;
    }
    if (server.hasArg("bt_font_profile") || server.hasArg("bt_font_mode")) {
      int profile = server.arg("bt_font_profile").toInt();
      int mode = server.arg("bt_font_mode").toInt();
      if (!server.hasArg("bt_font_profile") || !server.hasArg("bt_font_mode") ||
          server.arg("bt_font_profile") != String(profile) || server.arg("bt_font_mode") != String(mode) ||
          profile < 0 || profile >= BT_WATCH_PROFILE_COUNT || mode < 0 || mode > 2) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid watch font selection\"}"); return;
      }
      const uint8_t previous = btFontMode[profile];
      btFontMode[profile] = mode;
      if (!writeConfigNow()) {
        btFontMode[profile] = previous; saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Watch font choice could not be saved; previous value retained\"}"); return;
      }
      server.send(200,"application/json","{\"status\":\"ok\"}"); return;
    }
    if (server.hasArg("bt_idle_power_save")) {
      String value = server.arg("bt_idle_power_save");
      if (value != "0" && value != "1" && value != "true" && value != "false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Bluetooth power-save value\"}"); return;
      }
      const bool previous = btIdlePowerSaveEnabled;
      btIdlePowerSaveEnabled = value == "1" || value == "true";
      if (!writeConfigNow()) {
        btIdlePowerSaveEnabled = previous; saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth power saving could not be saved; previous value retained\"}"); return;
      }
      server.send(200,"application/json","{\"status\":\"ok\"}"); return;
    }
    // LED changes do not interfere with a watch
    // transaction. Commit to flash before reporting that the switch is saved.
    if (server.hasArg("activity_led_enabled")) {
      String value = server.arg("activity_led_enabled");
      if (value != "0" && value != "1" && value != "true" && value != "false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid activity LED value\"}");
        return;
      }
      const bool previousEnabled = activityLedEnabled.load();
      activityLedEnabled = value == "1" || value == "true";
      if (!writeConfigNow()) {
        activityLedEnabled = previousEnabled;
        saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Activity LED setting could not be saved; previous value retained\"}");
        return;
      }
      server.send(200,"application/json","{\"status\":\"ok\"}");
      return;
    }
    // Settings can be updated independently.
    char previousSsid[sizeof(ssid)], previousPassword[sizeof(passwd)], previousDisplayZone[32];
    strlcpy(previousSsid,ssid,sizeof(previousSsid));
    strlcpy(previousPassword,passwd,sizeof(previousPassword));
    if (timezone_name.length() >= sizeof(previousDisplayZone)) {
      server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Display time zone unavailable; settings retained\"}"); return;
    }
    strlcpy(previousDisplayZone,timezone_name.c_str(),sizeof(previousDisplayZone));
    const int previousPowerMode=wifiPowerMode;
    const bool previousAlwaysWait=btAlwaysWaitEnabled;
    const bool ssidRequested=server.hasArg("ssid"), passwordRequested=server.hasArg("password");
    const bool displayZoneRequested=server.hasArg("timezone");
    String requestedSsid, requestedPassword, requestedDisplayZone;
    if (ssidRequested && (!server.checkedArg("ssid",requestedSsid) || requestedSsid.length()>32 ||
        strlen(requestedSsid.c_str())!=requestedSsid.length() || requestedSsid.indexOf("\r")>=0 || requestedSsid.indexOf("\n")>=0)) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"SSID must be at most 32 UTF-8 bytes without line breaks\"}"); return;
    }
    if (passwordRequested && (!server.checkedArg("password",requestedPassword) || requestedPassword.length()>=sizeof(passwd) ||
        strlen(requestedPassword.c_str())!=requestedPassword.length() || requestedPassword.indexOf("\r")>=0 || requestedPassword.indexOf("\n")>=0)) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Wi-Fi password must be at most 63 bytes without line breaks\"}"); return;
    }
    if (displayZoneRequested && (!server.checkedArg("timezone",requestedDisplayZone) || !validTimezoneName(requestedDisplayZone))) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Unsupported display time zone\"}"); return;
    }
    int requestedPowerMode=previousPowerMode;
    bool requestedAlwaysWait=previousAlwaysWait;
    if (server.hasArg("wifi_power_mode")) {
      const String value=server.arg("wifi_power_mode");
      if (value!="0" && value!="1") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Wi-Fi power mode\"}"); return;
      }
      requestedPowerMode=value=="1"?WIFI_POWER_SCHEDULED:WIFI_POWER_ALWAYS_ON;
    }
    if (server.hasArg("bt_always_wait")) {
      const String value=server.arg("bt_always_wait");
      if (value!="0" && value!="1" && value!="true" && value!="false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Always Wait value\"}"); return;
      }
      requestedAlwaysWait=value=="1" || value=="true";
    }
    const char *nextDisplayZone=displayZoneRequested?requestedDisplayZone.c_str():previousDisplayZone;
    const bool wifiChanged=(ssidRequested && strcmp(previousSsid,requestedSsid.c_str())) ||
                           (passwordRequested && requestedPassword.length()>0 && strcmp(previousPassword,requestedPassword.c_str()));

    // Stage both BT civil-time fields before changing any live BT setting.
    // Wi-Fi requests still reach their existing commit paths.
    const bool btZoneRequested = server.hasArg("bt_timezone");
    const bool btOffsetRequested = server.hasArg("bt_time_offset_minutes");
    char previousBtZone[32]; // All supported zone names fit, including NUL.
    if (btTimezoneName.length() >= sizeof(previousBtZone)) {
      server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth time zone unavailable; settings retained\"}"); return;
    }
    strlcpy(previousBtZone, btTimezoneName.c_str(), sizeof(previousBtZone));
    const int previousBtOffset = btTimeOffsetMinutes;
    String requestedBtZone;
    int requestedBtOffset = previousBtOffset;
    if (btZoneRequested) {
      if (!server.checkedArg("bt_timezone", requestedBtZone)) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Not enough memory to read Bluetooth time zone; settings retained\"}"); return;
      }
      if (!validTimezoneName(requestedBtZone)) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Unsupported Bluetooth time zone\"}"); return;
      }
    }
    if (btOffsetRequested) {
      String requestedOffset;
      if (!server.checkedArg("bt_time_offset_minutes", requestedOffset)) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Not enough memory to read Bluetooth time offset; settings retained\"}"); return;
      }
      requestedBtOffset = requestedOffset.toInt();
      if (requestedOffset != String(requestedBtOffset) || requestedBtOffset < -720 || requestedBtOffset > 840) {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Bluetooth time offset\"}"); return;
      }
    }
    const char *nextBtZone = btZoneRequested ? requestedBtZone.c_str() : previousBtZone;
    const bool btTimeSettingsChanged = strcmp(nextBtZone, previousBtZone) != 0 ||
                                       requestedBtOffset != previousBtOffset;
    if (btTimeSettingsChanged && btBleBusy) {
      server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth transaction is active; retry time settings when it finishes\"}"); return;
    }
    const auto commitConfigWithBtTime = [&]() -> bool {
      const size_t oldDisplayLength=strlen(previousDisplayZone), nextDisplayLength=strlen(nextDisplayZone);
      if (!timezone_name.reserve(oldDisplayLength>nextDisplayLength?oldDisplayLength:nextDisplayLength))
        return configSaveFailed("Display time-zone allocation");

      if (btTimeSettingsChanged) {
        // Reserve once for both apply and rollback; neither assignment can
        // allocate after this succeeds. The rollback copy is fixed on stack.
        const size_t previousLength = strlen(previousBtZone);
        const size_t nextLength = strlen(nextBtZone);
        if (!btTimezoneName.reserve(previousLength > nextLength ? previousLength : nextLength))
          return configSaveFailed("Bluetooth time-zone allocation");
        btTimezoneName = nextBtZone;
        btTimeOffsetMinutes = requestedBtOffset;
      }
      if (ssidRequested) strlcpy(ssid,requestedSsid.c_str(),sizeof(ssid));
      if (passwordRequested && requestedPassword.length()>0) strlcpy(passwd,requestedPassword.c_str(),sizeof(passwd));
      timezone_name=nextDisplayZone;
      wifiPowerMode=requestedPowerMode; btAlwaysWaitEnabled=requestedAlwaysWait;
      if (!writeConfigNow()) {
        strlcpy(ssid,previousSsid,sizeof(ssid)); strlcpy(passwd,previousPassword,sizeof(passwd));
        timezone_name=previousDisplayZone; wifiPowerMode=previousPowerMode; btAlwaysWaitEnabled=previousAlwaysWait;

        if (btTimeSettingsChanged) {
          btTimezoneName = previousBtZone;
          btTimeOffsetMinutes = previousBtOffset;
        }
        return false;
      }
      if (strcmp(nextDisplayZone,previousDisplayZone)) applyTimezone();
      if (wifiChanged) wifiCredentialsReconnectPending=true;
      if (btTimeSettingsChanged) {
        // Only automatic windows are rearmed. An active one is stopped using
        // the existing host barrier, then reopened for the new BT civil time
        // on the next service pass. Manual/Pair/Always Wait stay intact.
        for (int i = 0; i < BT_SYNC_SLOT_COUNT; ++i) resetBluetoothSlotAttempt(i);
      }
      return true;
    };

    if (server.hasArg("bt_manual_protocol")) {
      int p = server.arg("bt_manual_protocol").toInt();
      if (server.arg("bt_manual_protocol") != String(p) || !validBtProtocol(p) ||
          !bluetoothSettingsMutable()) {
        server.send(409, "application/json", "{\"status\":\"error\",\"message\":\"invalid protocol or Bluetooth window is active\"}");
        return;
      }
      const uint8_t previousProtocol = btManualProtocol;
      btManualProtocol = (uint8_t)p;
      if (!commitConfigWithBtTime()) {
        btManualProtocol = previousProtocol; saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}"); return;
      }
      server.send(200, "application/json", "{\"status\":\"ok\"}");
      return;
    }
    if (server.hasArg("bt_manual_profile")) {
      int p=server.arg("bt_manual_profile").toInt();
      if (server.arg("bt_manual_profile") != String(p) || p<0 || p>=BT_WATCH_PROFILE_COUNT || !bluetoothSettingsMutable()) {
        server.send(409,"application/json","{\"status\":\"error\",\"message\":\"invalid/busy profile\"}");return;
      }
      const uint8_t previousProfile = btManualProfile;
      btManualProfile=(uint8_t)p;
      if (!commitConfigWithBtTime()) {
        btManualProfile = previousProfile; saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}"); return;
      }
      server.send(200,"application/json","{\"status\":\"ok\"}");return;
    }
    if (server.hasArg("bt_rebind_profile")) {
      // Legacy clients must use the explicit, transactional Pair Watch route.
      server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Use Pair Watch; the existing binding is retained until replacement succeeds\"}");
      return;
    }
    if (server.hasArg("bt_slot")) {
      int slot = server.arg("bt_slot").toInt();
      if (server.arg("bt_slot") != String(slot) || slot < 0 || slot >= BT_SYNC_SLOT_COUNT) {
        server.send(400, "application/json", "{\"status\":\"error\",\"message\":\"invalid Bluetooth slot\"}");
        return;
      }
      if (server.hasArg("bt_slot_time")) {
        String requested=server.arg("bt_slot_time");
        int m=requested.toInt();
        if (requested != String(m) || m<0 || m>=1440 ||
            btOverlapsOtherEnabledSlot(slot,m) || !bluetoothSlotSettingsMutable()) {
          server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Time invalid, busy, or overlaps another Bluetooth window\"}"); return;
        }
        const int previousTime = btSyncTimes[slot];
        btSyncTimes[slot] = m;
        if (!commitConfigWithBtTime()) {
          btSyncTimes[slot] = previousTime; saveConfig();
          server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}"); return;
        }
        if (previousTime != m) resetBluetoothSlotAttempt(slot);
        server.send(200,"application/json","{\"status\":\"ok\"}");return;
      }
      if (server.hasArg("bt_slot_profile")) {
        int p=server.arg("bt_slot_profile").toInt();
        if (server.arg("bt_slot_profile") != String(p) || p<0 || p>=BT_WATCH_PROFILE_COUNT || !bluetoothSlotSettingsMutable()) {
          server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Invalid/busy watch profile\"}");return;
        }
        // One logical watch has one protocol across its enabled sync slots.
        for (int i=0;i<BT_SYNC_SLOT_COUNT;++i)
          if (i!=slot && btSyncEnabled[i] && btSyncProfile[i]==p &&
              btSyncProtocol[i]!=btSyncProtocol[slot]) {
            server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Watch profile uses another protocol\"}");return;
          }
        const uint8_t previousProfile = btSyncProfile[slot];
        btSyncProfile[slot] = (uint8_t)p;
        if (!commitConfigWithBtTime()) {
          btSyncProfile[slot] = previousProfile; saveConfig();
          server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}"); return;
        }
        if (previousProfile != p) resetBluetoothSlotAttempt(slot);
        server.send(200,"application/json","{\"status\":\"ok\"}");return;
      }
      if (server.hasArg("bt_slot_protocol")) {
        int p = server.arg("bt_slot_protocol").toInt();
        if (server.arg("bt_slot_protocol") != String(p) || !validBtProtocol(p) ||
            !bluetoothSlotSettingsMutable()) {
          server.send(409, "application/json", "{\"status\":\"error\",\"message\":\"invalid protocol or Bluetooth window is active\"}");
          return;
        }
        for (int i=0;i<BT_SYNC_SLOT_COUNT;++i)
          if (i!=slot && btSyncEnabled[i] && btSyncProfile[i]==btSyncProfile[slot] &&
              btSyncProtocol[i]!=p) {
            server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Watch profile uses another protocol\"}");return;
          }
        const uint8_t previousProtocol = btSyncProtocol[slot];
        btSyncProtocol[slot] = (uint8_t)p;
        if (!commitConfigWithBtTime()) {
          btSyncProtocol[slot] = previousProtocol; saveConfig();
          server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}"); return;
        }
        if (previousProtocol != p) resetBluetoothSlotAttempt(slot);
        server.send(200, "application/json", "{\"status\":\"ok\"}");
        return;
      }
      if (!server.hasArg("bt_slot_enabled")) {
        server.send(400, "application/json", "{\"status\":\"error\",\"message\":\"Bluetooth slot update missing enabled value\"}");
        return;
      }
      const String enabledValue=server.arg("bt_slot_enabled");
      if (enabledValue!="0" && enabledValue!="1" && enabledValue!="true" && enabledValue!="false") {
        server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Bluetooth slot enabled value\"}"); return;
      }
      const bool en=enabledValue=="1" || enabledValue=="true";
      if (en && btOverlapsOtherEnabledSlot(slot,btSyncTimes[slot])) {
        server.send(409, "application/json",
                    "{\"status\":\"error\",\"message\":\"Bluetooth time overlaps another listening window\"}");
        return;
      }
      if (btBleBusy && btSyncActiveSlot == slot) {
        server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth transaction is active; retry when it finishes\"}");
        return;
      }
      const bool previousEnabled = btSyncEnabled[slot];
      btSyncEnabled[slot] = en;
      // A recurring listening switch must survive an immediate power cycle.
      // Acknowledge only after the atomic flash replacement has succeeded.
      if (!commitConfigWithBtTime()) {
        btSyncEnabled[slot] = previousEnabled;
        saveConfig();
        server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Bluetooth setting could not be saved; previous value retained\"}");
        return;
      }
      if (previousEnabled != en || !en) resetBluetoothSlotAttempt(slot);
      server.send(200, "application/json", "{\"status\":\"ok\"}");
      return;
    }


    if (!commitConfigWithBtTime()) {
      server.send(500,"application/json",btTimeSettingsChanged
        ? "{\"status\":\"error\",\"message\":\"Settings not saved to flash; previous Bluetooth time settings retained. Retry Save before restarting\"}"
        : "{\"status\":\"error\",\"message\":\"Settings not saved to flash; previous settings retained\"}");
      return;
    }

    server.send(200, "application/json", "{\"status\":\"ok\"}");

  });

  // Primary status endpoint reports the display and Bluetooth civil clocks.
  server.on("/api/status", HTTP_GET, []() {
    const time_t utcNow = time(nullptr);
    struct tm local; localtime_r(&utcNow, &local);
    char localTime[16], localDate[16];
    strftime(localTime, sizeof(localTime), "%H:%M:%S", &local);
    strftime(localDate, sizeof(localDate), "%Y-%m-%d", &local);
    struct tm btTm; bluetoothLocalTime(utcNow, btTm);
    char btTime[32]; strftime(btTime, sizeof(btTime), "%Y-%m-%d %H:%M:%S", &btTm);
    CasioJsonWriter json(apiResponseBuffer, sizeof(apiResponseBuffer));
    json.append("{\"time\":").quoted(localTime);
    json.key("date").quoted(localDate);
    json.key("bt_time").quoted(btTime);
    json.key("bt_local_time").quoted(btTime);
    appendCommonSettings(json);
    portENTER_CRITICAL(&clockMux);
    const double drift = ntpDriftPpm;
    portEXIT_CRITICAL(&clockMux);
    json.key("ntp_interval").number(ntpIntervalSec.load());
    json.key("ntp_drift_ppm").real(drift);
    json.key("clock_state").quoted(clockConfidence());
    json.key("wifi_connected").boolean(WiFi.status() == WL_CONNECTED);
    const String wifiIp = WiFi.localIP().toString(), apIp = WiFi.softAPIP().toString();
    json.key("wifi_ip").quoted(wifiIp.c_str());
    json.key("ap_mode").boolean(ap_mode);
    json.key("ap_ip").quoted(apIp.c_str());
    json.key("uptime_sec").number(monotonicUptimeSeconds());
    const uint32_t age = clockAgeSeconds();
    json.key("ntp_age_sec").number(age == UINT32_MAX ? -1 : static_cast<int64_t>(age));
    json.key("clock_error_est_sec").real(clockEstimatedError());
    json.key("heap_free").number(ESP.getFreeHeap());
    json.key("littlefs_total").number(filesystemAvailable ? LittleFS.totalBytes() : 0);
    json.key("littlefs_used").number(filesystemAvailable ? LittleFS.usedBytes() : 0);
    json.key("bt_connection_attempts").number(btConnectionAttempts);
    json.key("bt_acked_writes").number(btWriteAcknowledgements);
    json.key("bt_response_errors").number(btResponseErrors.load());
    json.append("}");
    sendBoundedJson(json);
  });

  server.on("/api/diagnostics", HTTP_GET, []() {
    DynamicJsonDocument d(4096);
    if (!d.capacity()) { server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Insufficient heap for diagnostics\"}"); return; }
    d["reset_reason"]=(int)esp_reset_reason();
    d["heap_max_alloc"]=ESP.getMaxAllocHeap();
    d["loop_stack_min_free"]=uxTaskGetStackHighWaterMark(nullptr);
    d["loop_stack_min_free_observed"]=applicationLoopStackMinimum();
    d["led_stack_min_free"]=activityLedStackMinimum();
    d["monitor_stack_min_free"]=safetyMonitorStackMinimum();
    d["nimble_host_stack_min_free"]=bluetoothHostStackMinimum();
    d["loop_heartbeat_age_ms"]=applicationLoopAgeMs();
    d["firmware"]=FIRMWARE_VERSION;
    d["uptime_sec"]=monotonicUptimeSeconds();
    d["firmware_build"]=FIRMWARE_BUILD;
    d["filesystem_available"]=filesystemAvailable;
    d["config_storage_fault"]=configStorageFault;
    d["heap_free"]=ESP.getFreeHeap();
    d["heap_min_free"]=ESP.getMinFreeHeap();
    d["clock_state"]=clockConfidence();
    d["ntp_age_sec"]=clockAgeSeconds()==UINT32_MAX?-1:(int32_t)clockAgeSeconds();
    portENTER_CRITICAL(&clockMux);
    uint32_t syncCountSnapshot = clockNtpSyncCount;
    uint32_t rejectedCountSnapshot = clockNtpRejectedCount;
    const uint8_t candidateReplySnapshot = clockNtpCandidateReplyCount;
    const uint32_t reacquisitionSnapshot = clockNtpReacquisitionCount;
    double driftBoundSnapshot = clockDriftBoundPpm;
    portEXIT_CRITICAL(&clockMux);
    d["ntp_sync_count"]=syncCountSnapshot;
    d["ntp_rejected_count"]=rejectedCountSnapshot;
    d["ntp_candidate_replies"]=candidateReplySnapshot;
    d["ntp_reacquisitions"]=reacquisitionSnapshot;
    d["clock_drift_bound_ppm"]=driftBoundSnapshot;
    d["clock_error_est_sec"]=clockEstimatedError();
    d["ntp_interval_sec"]=ntpIntervalSec.load();
    d["wifi_connected"]=WiFi.status()==WL_CONNECTED;
    d["wifi_power_requested"]=wifiRadioEnabled;
    d["wifi_power_observed"]=WiFi.getMode()!=WIFI_OFF;
    d["wifi_power_fault"]=wifiPowerFault;
    d["wifi_power_fault_count"]=wifiPowerFaultCount;
    d["wifi_shutdown_pending"]=wifiPowerShutdownPending;
    d["wifi_ip"]=WiFi.localIP().toString();
    d["ap_mode"]=ap_mode;
    d["ap_ip"]=WiFi.softAPIP().toString();
    d["wifi_access_enabled"]=wifiAccessEnabled;
    d["wifi_access_start"]=wifiAccessStart;
    d["wifi_access_end"]=wifiAccessEnd;
    d["wifi_access_timezone"]=wifiAccessTimezone;
    d["wifi_access_active"]=wifiAccessWindowOpen();
    d["bt_controller_off"]=esp_bt_controller_get_status()==ESP_BT_CONTROLLER_STATUS_IDLE;
    d["bt_state"]=bluetoothStateText();
    d["bt_always_wait"]=btAlwaysWaitEnabled;
    d["bt_last_sync_date"]=btLastSyncDate;
    d["bt_last_sync_status"]=btLastSyncStatus;
    d["bt_last_sync_epoch"]=btLastSyncEpoch.load();
    d["bt_last_outcome_successful"]=btLastOutcomeSuccessful.load();
    d["bt_history_persist"]=btHistoryPersistEnabled;
    d["bt_history_saved_at"]=bluetoothHistorySavedAt();
    d["bt_history_save_status"]=btHistorySaveStatus;
    d["crash_dump_enabled"]=crashDumpEnabled;
    d["crash_dump_available"]=RadioCrashDumpGate::available();
    d["bt_window_active"]=btWindowActive.load();
    d["bt_pair_mode"]=btPairModeActive || btPairRequested;
    d["bt_connection_attempts"]=btConnectionAttempts;
    d["bt_acked_writes"]=btWriteAcknowledgements;
    d["bt_notifications"]=btNotifications.load();
    d["bt_response_errors"]=btResponseErrors.load();
    d["bt_delivery_evidence"]=btDeliveryEvidence;
    d["littlefs_total"]=filesystemAvailable ? LittleFS.totalBytes() : 0;
    d["littlefs_used"]=filesystemAvailable ? LittleFS.usedBytes() : 0;
    const size_t expected = measureJson(d);
    if (d.overflowed() || expected >= sizeof(apiResponseBuffer)) { server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Diagnostics response capacity exceeded\"}"); return; }
    const size_t written = serializeJson(d, apiResponseBuffer, sizeof(apiResponseBuffer));
    if (written != expected) { server.send(503,"application/json","{\"status\":\"error\",\"message\":\"Diagnostics serialization failed\"}"); return; }
    server.setContentLength(written);
    server.send(200, "application/json", String());
    server.sendContent(apiResponseBuffer, written);
  });

  server.on("/api/settings", HTTP_POST, []() {
    if (!server.hasArg("bt_always_wait")) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Missing Always Wait setting\"}"); return;
    }
    String v=server.arg("bt_always_wait");
    if (v!="0" && v!="1" && v!="true" && v!="false") {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid Always Wait value\"}"); return;
    }
    const bool previousAlwaysWait = btAlwaysWaitEnabled;
    btAlwaysWaitEnabled=(v=="1" || v=="true");
    if (!writeConfigNow()) {
      btAlwaysWaitEnabled = previousAlwaysWait; saveConfig();
      server.send(500,"application/json","{\"status\":\"error\",\"message\":\"Always Wait could not be saved; previous value retained\"}"); return;
    }
    if (!btAlwaysWaitEnabled && btPersistentWaitActive && !btBleBusy) {
      stopBluetoothWindow(); setBluetoothPhase("Idle");
    }
    server.send(200,"application/json","{\"status\":\"ok\"}");
  });

  server.on("/api/bluetooth-pair", HTTP_POST, []() {
    if (!clockTrusted()) {
      server.send(503,"application/json","{\"status\":\"error\",\"message\":\"No trusted NTP clock yet. Synchronize NTP first.\"}"); return;
    }
    if (btPairRequested || btPairModeActive) {
      server.send(200,"application/json","{\"status\":\"ok\",\"state\":\"Pairing\",\"message\":\"Pairing window already active\"}"); return;
    }
    if (btBleBusy) {
      CasioJsonWriter json(apiResponseBuffer, sizeof(apiResponseBuffer));
      json.append("{\"status\":\"error\",\"message\":").quoted(bluetoothStateText()).append("}");
      sendBoundedJson(json, 409); return;
    }
    if (!validBtProtocol(btManualProtocol) || btManualProfile>=BT_WATCH_PROFILE_COUNT) {
      server.send(400,"application/json","{\"status\":\"error\",\"message\":\"Invalid watch profile or protocol\"}"); return;
    }
    stopBluetoothWindow();
    btManualSyncRequested=false;
    btPairRequested=true;
    btLastSyncStatus=String("Pairing Watch ")+(btManualProfile+1)+": put the watch into pairing mode";
    server.send(200,"application/json","{\"status\":\"ok\",\"state\":\"Pairing\",\"message\":\"Pairing window opened; previous binding retained until time delivery succeeds\"}");
  });

  server.on("/api/bluetooth-sync", HTTP_POST, []() {
    if (!clockTrusted()) {
      server.send(503,"application/json","{\"status\":\"error\",\"message\":\"No trusted NTP clock yet. Synchronize NTP first.\"}"); return;
    }
    if (btPairRequested || btPairModeActive) {
      server.send(409,"application/json","{\"status\":\"error\",\"state\":\"Pairing\",\"message\":\"Pairing is active; finish pairing before Sync Now\"}"); return;
    }
    if (btProfileAddress[btManualProfile].length()!=17 || btProfileProtocol[btManualProfile]!=btManualProtocol) {
      server.send(409,"application/json","{\"status\":\"error\",\"message\":\"Pair Watch first for the selected profile and protocol\"}"); return;
    }
    // If a GATT transaction is finishing, queue the retry; otherwise next loop
    // stops/reopens the current passive/manual/automatic window safely.
    btManualSyncRequested=true;
    if (!btBleBusy) btLastSyncStatus="Waiting for watch";
    CasioJsonWriter json(apiResponseBuffer, sizeof(apiResponseBuffer));
    json.append("{\"status\":\"ok\",\"state\":").quoted(bluetoothStateText());
    json.key("message").quoted("Manual sync window will restart safely").append("}");
    sendBoundedJson(json);
  });

  // Request an immediate SNTP client restart from the web interface.
  server.on("/api/ntp-sync", HTTP_POST, []() {
    if (WiFi.status() != WL_CONNECTED) {
      server.send(503, "application/json",
                  "{\"status\":\"error\",\"message\":\"Wi-Fi is not connected\"}");
      return;
    }
    // A first-boot AP or failed/late association may never have initialized
    // SNTP. Restarting a stopped client silently does nothing in the SDK.
    if (esp_sntp_enabled()) {
      if (!sntp_restart()) {
        server.send(503,"application/json","{\"status\":\"error\",\"message\":\"NTP restart failed; retry synchronization\"}"); return;
      }
    } else if (!configureNtpClient()) {
      server.send(503,"application/json","{\"status\":\"error\",\"message\":\"NTP client could not be started; retry synchronization\"}"); return;
    }
    Serial.println("NTP sync requested from web UI");
    server.send(200, "application/json",
                "{\"status\":\"ok\",\"message\":\"NTP synchronization requested\"}");
  });

  webRoutesRegistered=true;
  }
  server.begin(); webServerStarted=true;
}

static const uint8_t INDEX_HTML_GZ[] PROGMEM = {
  0x1f, 0x8b, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xe4, 0xbd, 0xd9, 0x96, 0xdb, 0x48, 0x96, 0x20, 0xf8, 0xae,
  0xaf, 0x80, 0x5c, 0x0a, 0x91, 0x2c, 0x91, 0x74, 0x82, 0xbb, 0x93, 0xa2, 0xfb, 0x28, 0x24, 0x45, 0x86, 0xa6, 0xa4, 0x88,
  0x18, 0x49, 0x91, 0x51, 0x95, 0x4a, 0xb5, 0x02, 0x24, 0x40, 0x77, 0xa4, 0x48, 0x82, 0x45, 0x80, 0xbe, 0xa4, 0x8b, 0xe7,
  0xe4, 0xd3, 0x9c, 0x79, 0x98, 0x97, 0xee, 0x53, 0x4f, 0xf3, 0x01, 0xfd, 0x0b, 0xfd, 0xde, 0x9f, 0x92, 0x5f, 0x32, 0x77,
  0x31, 0x33, 0x98, 0x01, 0x06, 0x90, 0x2e, 0x29, 0xab, 0xeb, 0x9c, 0xce, 0xc5, 0x45, 0x00, 0xb6, 0x5e, 0xbb, 0x76, 0x77,
  0xbb, 0xf6, 0xe4, 0xfe, 0xf3, 0x9f, 0x9f, 0xbd, 0xfb, 0xd7, 0x5f, 0x5e, 0x38, 0x17, 0xc9, 0x72, 0x71, 0x7a, 0xef, 0x09,
  0xfe, 0xe3, 0x2c, 0xbc, 0xd5, 0xf9, 0xe4, 0x28, 0x58, 0x1d, 0xe1, 0x8b, 0xc0, 0xf3, 0xe1, 0x9f, 0x65, 0x90, 0x78, 0xce,
  0xec, 0xc2, 0xdb, 0xc4, 0x41, 0x32, 0x39, 0xfa, 0xf5, 0xdd, 0x0f, 0x8d, 0xe1, 0x91, 0x7c, 0xbd, 0xf2, 0x96, 0xc1, 0xe4,
  0xe8, 0x32, 0x0c, 0xae, 0xd6, 0xd1, 0x26, 0x39, 0x72, 0x66, 0xd1, 0x2a, 0x09, 0x56, 0x50, 0xec, 0x2a, 0xf4, 0x93, 0x8b,
  0x89, 0x1f, 0x5c, 0x86, 0xb3, 0xa0, 0x41, 0x0f, 0xf5, 0x70, 0x15, 0x26, 0xa1, 0xb7, 0x68, 0xc4, 0x33, 0x6f, 0x11, 0x4c,
  0xdc, 0xba, 0xac, 0xd5, 0x98, 0x87, 0xc9, 0x64, 0x16, 0x5d, 0x06, 0x9b, 0x4c, 0xb3, 0xb3, 0x68, 0x11, 0x6d, 0xa0, 0xf8,
  0x45, 0xb0, 0x0c, 0xb4, 0xa6, 0x7d, 0x6f, 0xf3, 0xc9, 0x59, 0x84, 0xe7, 0x17, 0x09, 0x96, 0x4f, 0xc2, 0x64, 0x11, 0x9c,
  0x3e, 0xf3, 0xe2, 0x30, 0x7a, 0x7b, 0xb3, 0x9a, 0x3d, 0x39, 0xe6, 0x17, 0xf7, 0x9e, 0xc4, 0xc9, 0x0d, 0xfe, 0x3b, 0xda,
  0x44, 0x51, 0x72, 0x7b, 0xcf, 0x69, 0x34, 0xa6, 0xe7, 0xa3, 0x07, 0xf3, 0xee, 0xbc, 0x3f, 0xf7, 0xc6, 0x8d, 0xc6, 0xda,
  0x5b, 0x05, 0x0b, 0x78, 0xa6, 0xff, 0xc8, 0xe7, 0x36, 0xbc, 0x18, 0xce, 0xbd, 0xf9, 0x0c, 0x5e, 0x84, 0xab, 0x4f, 0xa3,
  0x07, 0x6e, 0xcb, 0x1d, 0xb6, 0x87, 0xf0, 0xb4, 0xdc, 0x26, 0x81, 0x3f, 0x7a, 0xd0, 0xef, 0x0f, 0x5a, 0xc3, 0x1e, 0x3c,
  0x2f, 0xc2, 0x55, 0x30, 0x7a, 0x10, 0x74, 0x83, 0x41, 0x30, 0x1b, 0x53, 0xe3, 0x1b, 0x6f, 0x05, 0x05, 0xdc, 0x5e, 0x2f,
  0x08, 0xb0, 0x3d, 0x7a, 0x86, 0xf6, 0x5a, 0xad, 0x6e, 0x10, 0x4c, 0xe1, 0xc5, 0x79, 0x14, 0xc1, 0xf7, 0x56, 0x7f, 0xd0,
  0xef, 0x0e, 0xc4, 0x23, 0x0e, 0x28, 0x98, 0xcd, 0xfd, 0x79, 0x07, 0x5e, 0x5c, 0x79, 0x9b, 0xd5, 0xe8, 0xc1, 0xb4, 0xd7,
  0x85, 0x1e, 0xc4, 0x23, 0x0d, 0x78, 0x3e, 0xf7, 0xa0, 0x3e, 0x75, 0xe1, 0x41, 0x03, 0xd3, 0x6e, 0xbb, 0xe3, 0x62, 0x01,
  0x78, 0xa2, 0xef, 0xc1, 0xbc, 0x33, 0x6f, 0xc3, 0x73, 0x34, 0x9f, 0x8f, 0x1e, 0x74, 0x07, 0xbd, 0x6e, 0x1f, 0x9b, 0x8f,
  0x2f, 0x3c, 0x3f, 0xba, 0x1a, 0xb5, 0x1c, 0xb7, 0xbf, 0xbe, 0x76, 0xba, 0x6d, 0xf8, 0xb3, 0x39, 0x9f, 0x7a, 0x55, 0xb7,
  0x5f, 0x6f, 0x77, 0xeb, 0xdd, 0x56, 0xbd, 0xd9, 0x1a, 0xd6, 0xa8, 0xd5, 0x8d, 0xe7, 0x87, 0xdb, 0x78, 0xe4, 0x0e, 0xd7,
  0xd7, 0x50, 0x2f, 0xf1, 0xd6, 0xa3, 0x2e, 0x54, 0xb9, 0xb7, 0xbb, 0xf7, 0x7f, 0x2c, 0x03, 0x3f, 0xf4, 0xaa, 0xeb, 0x4d,
  0x30, 0x0f, 0x36, 0x71, 0x43, 0x5f, 0x8c, 0x11, 0x2e, 0x41, 0xed, 0xd6, 0x04, 0x6d, 0x6b, 0xda, 0x9a, 0xbb, 0xfd, 0x14,
  0xb4, 0x6e, 0x1b, 0x60, 0xd7, 0xd1, 0x40, 0xeb, 0x0e, 0xdc, 0x79, 0x5b, 0x81, 0x76, 0xde, 0x86, 0xb5, 0x18, 0xa4, 0xa0,
  0x3d, 0x19, 0x7a, 0xed, 0x69, 0x47, 0x81, 0xb6, 0x3d, 0xe8, 0xb4, 0xbb, 0x5d, 0x1d, 0xb4, 0xc3, 0xae, 0xe7, 0xcf, 0x75,
  0xd0, 0xf6, 0xda, 0xc3, 0x29, 0xbd, 0x60, 0xd0, 0x0e, 0x7a, 0x41, 0xcb, 0xd3, 0x41, 0xdb, 0x1a, 0x76, 0xa6, 0xed, 0x81,
  0x02, 0xed, 0x3c, 0x98, 0x0d, 0xbb, 0x53, 0x0d, 0xb4, 0x1d, 0xaf, 0x7d, 0xd2, 0xd2, 0x40, 0x3b, 0xf7, 0xe1, 0xc5, 0x34,
  0x05, 0x6d, 0x67, 0xea, 0xba, 0x6e, 0x4b, 0x82, 0x56, 0x8d, 0x4f, 0x81, 0xb6, 0xdd, 0x02, 0xa8, 0xf6, 0x14, 0x68, 0x5b,
  0x75, 0xfc, 0x6f, 0xb3, 0x3d, 0xac, 0xdd, 0xdb, 0xed, 0xee, 0xfd, 0xd3, 0xed, 0x34, 0xba, 0x6e, 0xc4, 0xe1, 0x5f, 0xc3,
  0xd5, 0xf9, 0x68, 0x1a, 0x6d, 0xfc, 0x60, 0xd3, 0x80, 0x37, 0x3b, 0xdc, 0x64, 0xb7, 0xf1, 0x6c, 0x13, 0x2d, 0x16, 0x8d,
  0x69, 0x70, 0xe1, 0x5d, 0x86, 0xd1, 0x66, 0x14, 0x2f, 0x01, 0x90, 0x17, 0xbb, 0x69, 0xe4, 0xdf, 0xdc, 0x2e, 0xbd, 0xcd,
  0x79, 0xb8, 0x1a, 0xb5, 0xc6, 0x53, 0x6f, 0xf6, 0xe9, 0x7c, 0x13, 0x6d, 0x61, 0xee, 0x97, 0xde, 0xa6, 0x8a, 0x40, 0xae,
  0x8d, 0x69, 0x15, 0xc4, 0x33, 0x80, 0xb1, 0x36, 0x9e, 0xc3, 0xae, 0x18, 0xb9, 0xbd, 0xf5, 0xf5, 0xb1, 0xdb, 0xec, 0xf6,
  0x9c, 0xf8, 0x26, 0x4e, 0x82, 0x65, 0x63, 0x1b, 0xd6, 0x1b, 0xde, 0x7a, 0xbd, 0x08, 0x1a, 0xfc, 0xa2, 0xfe, 0x3d, 0x40,
  0xf5, 0xd3, 0x6b, 0x6f, 0xf6, 0x96, 0x1e, 0x7f, 0x80, 0x4a, 0xf5, 0xa3, 0xb7, 0xc1, 0x79, 0x14, 0x38, 0xbf, 0xbe, 0x3c,
  0xaa, 0xc7, 0xde, 0x2a, 0x6e, 0xc4, 0xc1, 0x26, 0x9c, 0xef, 0xee, 0x4d, 0xb7, 0x49, 0x12, 0xad, 0x60, 0xb3, 0xae, 0xb7,
  0x49, 0x3d, 0x0e, 0x16, 0xc1, 0x2c, 0xb9, 0xa5, 0x4e, 0xc2, 0xd5, 0x05, 0x94, 0x48, 0x76, 0x5c, 0xe0, 0x76, 0x19, 0xae,
  0x1a, 0x17, 0x01, 0xee, 0x42, 0x31, 0x1c, 0x40, 0x9d, 0xda, 0xee, 0x5e, 0x33, 0xbe, 0x08, 0x16, 0x0b, 0x98, 0xc5, 0x35,
  0xef, 0xfa, 0x91, 0xeb, 0x0e, 0x01, 0x4e, 0x63, 0x31, 0x2d, 0x6f, 0x9b, 0x44, 0xe3, 0xb5, 0xe7, 0xfb, 0x08, 0x16, 0x02,
  0x20, 0x22, 0x9e, 0xd3, 0xed, 0xae, 0xaf, 0x77, 0xcd, 0xa5, 0x17, 0x27, 0xb7, 0x7e, 0x18, 0xaf, 0x17, 0xde, 0xcd, 0x68,
  0xbe, 0x08, 0xae, 0xc7, 0x1e, 0x6c, 0xf3, 0x55, 0x23, 0x84, 0x21, 0xc7, 0xa3, 0x19, 0x6c, 0xfe, 0x60, 0x33, 0xfe, 0xcb,
  0x36, 0x4e, 0xc2, 0xf9, 0x4d, 0x43, 0x90, 0x83, 0x51, 0xbc, 0xf6, 0x80, 0xc2, 0x4c, 0x83, 0xe4, 0x2a, 0x08, 0x56, 0xe3,
  0x73, 0xc0, 0x5f, 0x44, 0x79, 0xd1, 0x1f, 0x80, 0x1c, 0x06, 0xbb, 0x24, 0xec, 0x86, 0xb1, 0x11, 0xe6, 0xec, 0xed, 0x81,
  0xda, 0x68, 0xe3, 0x80, 0x16, 0xd1, 0x79, 0x74, 0xcb, 0xd3, 0xc0, 0x2d, 0x34, 0x16, 0xf3, 0xa5, 0xdf, 0x62, 0x4d, 0xe5,
  0xf6, 0xe9, 0xe0, 0xab, 0x74, 0xc5, 0x10, 0x89, 0xbd, 0x4d, 0xe3, 0x1c, 0x3f, 0x43, 0xab, 0x55, 0xb7, 0xdb, 0xf3, 0x83,
  0xf3, 0xba, 0x58, 0x48, 0x1c, 0x46, 0xad, 0xfe, 0x60, 0x30, 0xef, 0xf5, 0xfd, 0x93, 0xda, 0x58, 0x0e, 0xe8, 0x7c, 0x13,
  0xfa, 0x63, 0xf8, 0x05, 0xf3, 0x31, 0x06, 0xc4, 0x8b, 0x8e, 0xa4, 0x80, 0x96, 0xbb, 0x71, 0xc5, 0xc3, 0x38, 0x69, 0x01,
  0x92, 0x20, 0x92, 0x49, 0x84, 0x44, 0x48, 0x12, 0x4c, 0x09, 0x1f, 0xdb, 0x6e, 0xfd, 0xa4, 0x5b, 0x6f, 0x77, 0x4e, 0x00,
  0x27, 0x7b, 0x35, 0x39, 0x7b, 0xe7, 0xc2, 0xa5, 0xe5, 0x44, 0xd4, 0x0c, 0x68, 0x05, 0xc6, 0x38, 0x56, 0xb9, 0x94, 0x6e,
  0xd3, 0x95, 0x4b, 0xd5, 0xda, 0x89, 0x1a, 0xf1, 0xd2, 0x83, 0x15, 0x95, 0x83, 0x9c, 0x2e, 0xa2, 0xd9, 0x27, 0x03, 0x0f,
  0x69, 0x03, 0xd7, 0x24, 0xc4, 0x93, 0x68, 0x3d, 0xea, 0x20, 0xf0, 0x60, 0x81, 0x56, 0x80, 0x3c, 0x21, 0xe0, 0xca, 0x21,
  0x10, 0x47, 0xfa, 0x63, 0x69, 0x35, 0x1d, 0xab, 0x4b, 0xad, 0xfa, 0x40, 0x71, 0x78, 0x45, 0x4e, 0xd2, 0x05, 0x39, 0xc9,
  0xad, 0x47, 0xaf, 0xf5, 0x9d, 0xbe, 0x1c, 0x62, 0xf7, 0x52, 0xf5, 0x26, 0xd2, 0x87, 0x5b, 0xfd, 0xa3, 0xdb, 0x9e, 0x0e,
  0xfa, 0x1e, 0x7f, 0x84, 0xbd, 0x6f, 0x7c, 0x9b, 0xb7, 0xba, 0xdd, 0xce, 0x10, 0xa0, 0x07, 0xc8, 0x1f, 0xdd, 0x96, 0xad,
  0x70, 0x87, 0x56, 0x58, 0xb0, 0x0c, 0xa7, 0xf5, 0x1d, 0xfc, 0xf4, 0xdb, 0x27, 0x9d, 0x13, 0x20, 0x11, 0xf0, 0xbb, 0xd3,
  0xed, 0xb6, 0x7a, 0x5d, 0xc7, 0x6d, 0xb5, 0xbe, 0xab, 0xe9, 0x0b, 0x6a, 0x0e, 0xbb, 0x0d, 0xfb, 0x20, 0xdd, 0x1e, 0x5d,
  0x9a, 0x96, 0x5a, 0x60, 0x86, 0x0b, 0x3f, 0x64, 0x90, 0x06, 0xff, 0x34, 0x00, 0xa2, 0xf0, 0x26, 0x09, 0x90, 0x54, 0x6f,
  0x97, 0x2b, 0x40, 0x4a, 0x58, 0xf8, 0xf9, 0xc6, 0x71, 0xe7, 0x0c, 0xe1, 0x36, 0xa2, 0x2d, 0xb2, 0xd9, 0xf9, 0x02, 0x5a,
  0xbb, 0x08, 0x7d, 0x1f, 0x36, 0xcc, 0x3a, 0x8a, 0x43, 0x5c, 0xa3, 0xd1, 0x26, 0x80, 0xba, 0xe1, 0x65, 0x20, 0xa6, 0x3a,
  0xf2, 0xe6, 0xb0, 0x32, 0xb7, 0x72, 0x97, 0x1d, 0x1d, 0xa5, 0x25, 0xbd, 0x69, 0x0c, 0x1d, 0x24, 0xc1, 0x98, 0xd7, 0xa1,
  0xdd, 0x6b, 0xa5, 0x2b, 0xc1, 0x0f, 0xa5, 0x6b, 0x81, 0x6f, 0x41, 0x0a, 0x50, 0x80, 0x9b, 0x85, 0x9b, 0xd9, 0x22, 0xa8,
  0x33, 0x7b, 0xea, 0xb4, 0xeb, 0xee, 0xa0, 0x53, 0x6f, 0xf7, 0x7a, 0xf5, 0x66, 0xa7, 0x56, 0x4f, 0x00, 0x01, 0x61, 0x83,
  0x6f, 0xa0, 0x9c, 0xd3, 0xef, 0x03, 0xe4, 0x36, 0xd4, 0x4b, 0x63, 0x80, 0xbd, 0x20, 0xa6, 0x35, 0xdc, 0x56, 0x0f, 0x41,
  0x16, 0x85, 0x88, 0x48, 0x8d, 0xe0, 0x12, 0x4a, 0xc6, 0xa3, 0x55, 0xb4, 0x0a, 0x76, 0xcd, 0xe0, 0x26, 0x98, 0x6e, 0xa2,
  0x2b, 0x0d, 0xdd, 0x71, 0x57, 0x8f, 0x93, 0xe0, 0x3a, 0x69, 0x50, 0xc3, 0xf3, 0x68, 0xb3, 0x1c, 0x6d, 0xd7, 0xeb, 0x60,
  0x33, 0xf3, 0xe2, 0x60, 0xbc, 0x08, 0x12, 0x6c, 0x03, 0x09, 0x0a, 0x82, 0xbf, 0xe9, 0xba, 0xc1, 0x52, 0x2e, 0xd5, 0x6c,
  0xe0, 0x0f, 0xe6, 0x81, 0xb1, 0xfd, 0x86, 0x2d, 0xdc, 0x21, 0xe1, 0x79, 0x12, 0x2e, 0x03, 0xa6, 0x90, 0x83, 0x56, 0xcb,
  0x99, 0x2d, 0xbc, 0xe5, 0xba, 0xda, 0x85, 0xf1, 0xd5, 0x07, 0x97, 0x57, 0xf5, 0x01, 0xf4, 0x58, 0x3b, 0x76, 0x9d, 0x6d,
  0xd8, 0x58, 0x46, 0xab, 0x88, 0x88, 0x55, 0xfd, 0xed, 0x0f, 0xaf, 0xe1, 0x77, 0xe3, 0x4d, 0x70, 0xbe, 0x5d, 0x78, 0x9b,
  0xfa, 0xeb, 0x60, 0xb5, 0x88, 0xea, 0xea, 0x73, 0x76, 0x1c, 0x8d, 0x66, 0xab, 0x0f, 0x03, 0x11, 0xbb, 0x72, 0x00, 0xdb,
  0x9b, 0x76, 0x3a, 0xa0, 0x2b, 0xac, 0xf5, 0xad, 0x18, 0x9f, 0xdf, 0xf2, 0x7b, 0xbe, 0x0f, 0x6b, 0xf7, 0x6f, 0xdb, 0x70,
  0xf6, 0xe9, 0xf6, 0x00, 0xe4, 0xd8, 0x04, 0xeb, 0xc0, 0x4b, 0xaa, 0xdd, 0x3a, 0xa0, 0x47, 0x4d, 0xd1, 0x3c, 0xd9, 0x8d,
  0xdb, 0xa5, 0x7e, 0x88, 0x6e, 0x72, 0x9b, 0x8d, 0x99, 0xb7, 0x31, 0xb6, 0x06, 0xa3, 0x23, 0x31, 0xf7, 0x9a, 0x58, 0xf1,
  0x91, 0x0b, 0xb5, 0x00, 0x39, 0x42, 0xdf, 0xe1, 0xaf, 0xb8, 0x49, 0x6a, 0x59, 0x52, 0xd9, 0xd7, 0x70, 0x1c, 0x39, 0xd7,
  0x18, 0x59, 0x09, 0xe3, 0x52, 0x4b, 0x76, 0xb6, 0xf0, 0xa6, 0xc1, 0xe2, 0xb6, 0x9c, 0x1e, 0xe0, 0x70, 0xf5, 0x05, 0x01,
  0xf0, 0x1f, 0xbe, 0xb8, 0xad, 0x5e, 0xb0, 0x94, 0x9d, 0x5d, 0x7a, 0x8b, 0x2d, 0x2f, 0xa1, 0x6a, 0xaa, 0xd7, 0xd2, 0xe9,
  0x19, 0x8e, 0xf8, 0xea, 0x02, 0x48, 0x16, 0xd5, 0x0f, 0x00, 0xbf, 0xae, 0x36, 0xde, 0x3a, 0xb7, 0x97, 0xa8, 0x73, 0xf5,
  0x12, 0xd8, 0x60, 0xb8, 0x8e, 0xc3, 0x18, 0xf8, 0x1a, 0x48, 0xbe, 0x59, 0x2c, 0xdc, 0x4b, 0x40, 0xbf, 0xa2, 0xc3, 0x7b,
  0xcd, 0x95, 0x77, 0x79, 0xab, 0xf6, 0x2b, 0xf0, 0xcb, 0xd9, 0xa7, 0x1b, 0xda, 0x2e, 0x48, 0x64, 0xff, 0x0a, 0x82, 0x83,
  0x1f, 0x5c, 0x8f, 0x5c, 0x43, 0xc4, 0x60, 0xf1, 0x6e, 0x19, 0x5e, 0x57, 0xc3, 0x95, 0x13, 0xc3, 0x66, 0xac, 0xeb, 0xeb,
  0xeb, 0x9c, 0x00, 0x3d, 0xd3, 0x36, 0x63, 0x8d, 0xaa, 0xfa, 0x9b, 0x68, 0x0d, 0xc2, 0xfb, 0x02, 0x00, 0x0b, 0x6c, 0x61,
  0xbb, 0xa9, 0xe2, 0xd2, 0xde, 0x0d, 0x17, 0x7a, 0x1a, 0x2e, 0xe0, 0xef, 0xc3, 0x11, 0xb7, 0x97, 0x22, 0x6e, 0x86, 0x4e,
  0x0a, 0x46, 0xd8, 0xb5, 0xc8, 0xbc, 0xbd, 0x5a, 0x56, 0x30, 0xe8, 0x23, 0x82, 0x03, 0xb8, 0xa6, 0xc9, 0xea, 0x56, 0x0c,
  0xdc, 0x80, 0x8b, 0x36, 0x69, 0xdb, 0x9a, 0x65, 0xa6, 0xe3, 0x6a, 0xd3, 0x01, 0xa6, 0x84, 0x03, 0xc9, 0xa1, 0xe8, 0x6c,
  0xbb, 0x89, 0xa1, 0x19, 0x41, 0xb2, 0x64, 0xe7, 0x4d, 0x6f, 0x86, 0xd4, 0x37, 0xbf, 0xc1, 0x48, 0xca, 0xd3, 0x7b, 0xe6,
  0x15, 0x81, 0x45, 0x46, 0xfd, 0x49, 0xed, 0x74, 0x26, 0x79, 0xf8, 0x4a, 0xb6, 0x64, 0x30, 0xec, 0x5d, 0x13, 0x81, 0x79,
  0x07, 0xba, 0xe0, 0xb6, 0xeb, 0x80, 0xb6, 0x20, 0xc6, 0x81, 0x5c, 0x8b, 0x80, 0x16, 0x24, 0x82, 0xe4, 0x34, 0xa2, 0x04,
  0x54, 0x9b, 0x2b, 0xa1, 0x0c, 0xb6, 0x72, 0xfa, 0xe3, 0x6f, 0x40, 0x1c, 0xf8, 0x0b, 0x3f, 0xd4, 0x0c, 0x41, 0xd1, 0x5c,
  0xe1, 0x0e, 0x4a, 0x8e, 0xb6, 0x15, 0xee, 0x80, 0xa8, 0x43, 0x03, 0x6c, 0x02, 0x45, 0x09, 0x8c, 0x51, 0xba, 0xc7, 0x0d,
  0x57, 0x7c, 0x4b, 0x2e, 0x42, 0xdb, 0x14, 0xba, 0xfc, 0xd9, 0xb9, 0x68, 0xeb, 0xdb, 0x35, 0x15, 0x27, 0x91, 0x3e, 0x61,
  0x01, 0x54, 0x8c, 0x8b, 0x85, 0x1a, 0x7c, 0xd1, 0x88, 0x13, 0x6f, 0x93, 0x1c, 0x22, 0xac, 0xb6, 0xf3, 0xc2, 0x2a, 0xe1,
  0x64, 0xbc, 0x9d, 0xde, 0xee, 0x95, 0x87, 0xe4, 0xb8, 0x98, 0x5a, 0xc3, 0xe8, 0x62, 0x96, 0xb8, 0x48, 0x07, 0xfe, 0x62,
  0xc6, 0xd7, 0x1a, 0x2a, 0xc6, 0x97, 0xef, 0x3b, 0xe5, 0x7e, 0xb2, 0xf3, 0x3e, 0xb3, 0x8a, 0x16, 0x89, 0xd8, 0x30, 0xef,
  0x64, 0x1b, 0x37, 0xd6, 0xa1, 0x26, 0x32, 0x86, 0x2b, 0x12, 0x31, 0xcb, 0xa4, 0xbf, 0x81, 0xb6, 0x71, 0xb0, 0x3d, 0x37,
  0x2f, 0x46, 0x9c, 0x9c, 0x9c, 0x98, 0x32, 0xb6, 0x86, 0x63, 0x6d, 0x73, 0x8b, 0x80, 0xc2, 0x56, 0xce, 0x29, 0x80, 0xbc,
  0xe7, 0xc9, 0xeb, 0x4e, 0x1f, 0x7c, 0x4e, 0x4a, 0xe4, 0x96, 0x59, 0xb7, 0x34, 0x7b, 0xc3, 0x77, 0x35, 0xb3, 0x32, 0xaa,
  0x98, 0xf9, 0xca, 0xac, 0x78, 0x9a, 0x95, 0xf1, 0x5d, 0xa6, 0x72, 0x46, 0x04, 0x15, 0x3a, 0x83, 0x97, 0xeb, 0x17, 0x5e,
  0x99, 0x35, 0x47, 0xd3, 0x00, 0x56, 0x36, 0xd0, 0x85, 0x36, 0x66, 0xab, 0x83, 0x54, 0x40, 0x1b, 0xec, 0x13, 0xcf, 0x80,
  0x3c, 0x21, 0xb1, 0x7b, 0x86, 0x1d, 0xed, 0xee, 0x3d, 0x98, 0x26, 0x6f, 0x02, 0x5c, 0x27, 0xb4, 0xad, 0xbc, 0x0a, 0xe3,
  0xe4, 0xd4, 0x0f, 0x2f, 0x6f, 0xed, 0xd8, 0xbe, 0xb3, 0x16, 0x3e, 0xc5, 0x9d, 0x75, 0x8b, 0xa5, 0x46, 0xae, 0xc1, 0xe9,
  0x73, 0xa5, 0x1d, 0x66, 0x94, 0xa6, 0xa2, 0xa1, 0x31, 0xc5, 0xae, 0x26, 0xbe, 0x36, 0x70, 0xc1, 0x46, 0xde, 0xea, 0xe6,
  0x0a, 0x84, 0xd5, 0xc0, 0xd2, 0xd6, 0x54, 0x53, 0x41, 0xbb, 0xc3, 0xef, 0x76, 0xf7, 0x58, 0xa2, 0x30, 0x1b, 0xdf, 0xcf,
  0x93, 0x0b, 0x84, 0x02, 0xb1, 0x53, 0x69, 0xa3, 0xce, 0xc3, 0x60, 0xe1, 0xdf, 0x66, 0xb6, 0x30, 0xea, 0x2a, 0x86, 0x0a,
  0x2d, 0x94, 0x61, 0x10, 0xff, 0xc7, 0x9a, 0xe6, 0xdc, 0xed, 0xaa, 0xe5, 0x38, 0x8c, 0x5f, 0xba, 0x85, 0x5b, 0xc0, 0x62,
  0x1b, 0xd0, 0x39, 0x11, 0xd5, 0x8c, 0xb6, 0x09, 0x59, 0x57, 0x88, 0x59, 0xd0, 0xf0, 0x46, 0xf3, 0x68, 0xb6, 0x8d, 0xc5,
  0x20, 0xf9, 0x41, 0xb0, 0xc1, 0x86, 0x81, 0x6a, 0xa4, 0xb1, 0x9a, 0x24, 0x18, 0xff, 0x8b, 0x64, 0xb8, 0x48, 0x72, 0xe0,
  0x3a, 0x20, 0x42, 0x9a, 0x92, 0x03, 0xd0, 0x08, 0x8f, 0x68, 0x54, 0x6c, 0x52, 0x50, 0xa4, 0x02, 0xb8, 0xc1, 0x09, 0x9f,
  0x68, 0x75, 0x49, 0xe4, 0xd1, 0xd6, 0x9f, 0x99, 0x8f, 0xc6, 0xa8, 0x53, 0x88, 0xe9, 0x5c, 0xba, 0x84, 0x25, 0xbb, 0x2d,
  0xc1, 0x36, 0x72, 0xeb, 0x6a, 0x32, 0xe5, 0xc3, 0xa8, 0x0c, 0xc2, 0x98, 0xc6, 0x33, 0xba, 0x40, 0xb4, 0xbc, 0x95, 0x92,
  0x10, 0xe9, 0x28, 0xab, 0x20, 0x8e, 0xab, 0xcd, 0x93, 0x21, 0x97, 0x68, 0xae, 0x37, 0x21, 0xcc, 0xe4, 0xc6, 0xb2, 0xaf,
  0xc9, 0x98, 0xa5, 0xab, 0x84, 0x5c, 0x21, 0x8e, 0xe6, 0x89, 0x6d, 0x25, 0x04, 0x56, 0xd8, 0x51, 0x80, 0xab, 0xfa, 0xde,
  0xea, 0x1c, 0x86, 0x73, 0x38, 0x09, 0xc1, 0x29, 0xc0, 0x5a, 0x78, 0xd3, 0x45, 0xe0, 0xdf, 0x46, 0xc8, 0x05, 0x92, 0x9b,
  0x51, 0xb3, 0x27, 0x81, 0xb2, 0x8a, 0x92, 0x86, 0xb7, 0x80, 0x4d, 0x17, 0xf8, 0xdc, 0x01, 0x6d, 0x1e, 0x0d, 0xa3, 0x91,
  0xec, 0x07, 0xe7, 0x4b, 0xa4, 0xe6, 0x19, 0xb6, 0x58, 0x08, 0xc7, 0x52, 0x9c, 0x97, 0xcb, 0xd5, 0xcd, 0x9b, 0x59, 0xc8,
  0x2c, 0x03, 0x9d, 0x49, 0x82, 0xf2, 0xd5, 0x22, 0xdb, 0x89, 0x86, 0x1e, 0x43, 0xa1, 0x8b, 0x88, 0xcd, 0xd9, 0x19, 0xee,
  0x45, 0x14, 0x1a, 0x4b, 0xa1, 0xe8, 0x56, 0xb4, 0x2f, 0x8d, 0x6d, 0x84, 0x20, 0xe8, 0x5a, 0xcd, 0xb3, 0x00, 0xd6, 0x24,
  0x3a, 0x3f, 0x5f, 0x04, 0x0d, 0xd4, 0x62, 0xbf, 0x91, 0x5d, 0xac, 0x9c, 0xd8, 0x14, 0x2d, 0x97, 0xda, 0x40, 0x52, 0xee,
  0xca, 0xae, 0x0b, 0x6d, 0x4d, 0x31, 0xda, 0x59, 0xb4, 0xbe, 0x01, 0xfa, 0x9b, 0x91, 0x3f, 0xf5, 0x8f, 0xc4, 0x12, 0xf6,
  0x1a, 0x94, 0x32, 0xd4, 0x59, 0xa3, 0x04, 0x8c, 0x05, 0x57, 0x61, 0x32, 0xbb, 0xb8, 0xcd, 0x19, 0x30, 0xc6, 0x19, 0xb1,
  0x83, 0xdb, 0x97, 0x9c, 0x40, 0x33, 0x55, 0x0c, 0x05, 0xb5, 0x21, 0x5a, 0x86, 0x86, 0x49, 0xd9, 0xa6, 0x43, 0xa4, 0xf1,
  0x36, 0x6f, 0xf0, 0x08, 0x57, 0x71, 0x90, 0x00, 0xb2, 0x29, 0x15, 0x6a, 0x2c, 0x77, 0x4b, 0x6b, 0xac, 0x11, 0x78, 0x69,
  0x4b, 0xcb, 0x10, 0x7b, 0x25, 0x30, 0xb5, 0x14, 0x3c, 0x2d, 0xf8, 0x04, 0x6b, 0x02, 0x9b, 0xb7, 0xb8, 0xef, 0xbc, 0x55,
  0x2b, 0x27, 0x27, 0x21, 0x2b, 0x33, 0xe9, 0x19, 0x6d, 0x09, 0x6e, 0xb0, 0xe9, 0x0e, 0x63, 0xd9, 0x8d, 0x45, 0x60, 0x28,
  0xb4, 0xf2, 0x68, 0xf6, 0x4f, 0xfa, 0xbd, 0x08, 0xe6, 0x09, 0xe9, 0xa9, 0x52, 0x5f, 0x35, 0xac, 0x66, 0x39, 0xcb, 0x16,
  0x49, 0x19, 0x85, 0x78, 0x2f, 0x6d, 0xe7, 0xa0, 0x9f, 0xe5, 0x87, 0xaa, 0xad, 0x09, 0x73, 0xa8, 0xc6, 0x65, 0x18, 0x87,
  0x40, 0xac, 0x1e, 0x4b, 0x68, 0x49, 0xbe, 0xd6, 0xce, 0x60, 0xb5, 0x60, 0x5b, 0xe2, 0x33, 0x8a, 0x85, 0x08, 0xc3, 0x4e,
  0x8a, 0x3d, 0xa2, 0x55, 0x49, 0xfc, 0xd2, 0x06, 0x25, 0x11, 0xec, 0x5b, 0x89, 0xa0, 0x51, 0x79, 0x76, 0x11, 0xcc, 0x3e,
  0x69, 0x75, 0x8b, 0x48, 0x7c, 0x79, 0x35, 0xb9, 0x14, 0xa9, 0x7c, 0x4e, 0xbf, 0x50, 0x35, 0xfb, 0x97, 0x2a, 0xea, 0x3f,
  0x48, 0x0e, 0x3e, 0xad, 0x75, 0x3b, 0x42, 0x3b, 0x4b, 0x9f, 0x50, 0x26, 0xcf, 0x1b, 0x8f, 0x3a, 0x68, 0xe8, 0xa0, 0x2d,
  0x65, 0xd1, 0x27, 0xe0, 0x4b, 0xb4, 0x8a, 0xb8, 0xd1, 0xb9, 0xb7, 0x0c, 0x17, 0x37, 0xa3, 0x3b, 0x98, 0xaa, 0x76, 0x4d,
  0x10, 0xf0, 0x68, 0xd2, 0x12, 0xe5, 0x6d, 0xe2, 0x09, 0xd3, 0x16, 0x69, 0x58, 0x22, 0x6d, 0x01, 0x11, 0x10, 0x00, 0xba,
  0x08, 0x35, 0x83, 0x3f, 0xeb, 0xa4, 0x2c, 0x05, 0xec, 0x9a, 0xa0, 0x96, 0x26, 0x37, 0x3a, 0xa3, 0xf7, 0xbd, 0xf8, 0x22,
  0x28, 0x95, 0x8d, 0x3a, 0x59, 0xdb, 0x29, 0x29, 0x3c, 0x44, 0x2a, 0x4d, 0x4b, 0xba, 0x01, 0x80, 0x7b, 0x34, 0x94, 0xdb,
  0xbb, 0x08, 0x61, 0xba, 0x91, 0x36, 0x6b, 0xf8, 0x37, 0xe8, 0xa6, 0x98, 0x26, 0xec, 0x90, 0x43, 0x34, 0x6f, 0x97, 0xc5,
  0x93, 0x66, 0x87, 0x6d, 0xb6, 0x44, 0x92, 0x94, 0x58, 0xa4, 0x53, 0xfc, 0x60, 0xe5, 0x8b, 0x96, 0x01, 0x2b, 0x83, 0xbb,
  0x59, 0x96, 0xc8, 0xa0, 0xa7, 0xea, 0xb2, 0x96, 0x63, 0x53, 0x66, 0x54, 0x09, 0x52, 0x65, 0xf2, 0x1a, 0xcb, 0x3d, 0xf8,
  0x00, 0xc8, 0xdc, 0x20, 0xb3, 0xf8, 0x01, 0x93, 0xc3, 0xc9, 0x28, 0x4b, 0x34, 0x71, 0xa2, 0x3c, 0x0f, 0xdb, 0x89, 0x36,
  0x43, 0xa0, 0x47, 0x42, 0xbc, 0xe8, 0x77, 0x53, 0xb2, 0xd3, 0xb7, 0xf0, 0x9d, 0xe1, 0x41, 0x6e, 0x17, 0x61, 0x89, 0xaf,
  0x0b, 0xff, 0xa8, 0x61, 0x80, 0xdf, 0xe7, 0x7c, 0xd1, 0xf6, 0x5b, 0x0f, 0x61, 0xc7, 0x43, 0x64, 0xad, 0x2b, 0x6b, 0x33,
  0x94, 0x5f, 0xc9, 0x32, 0x7b, 0x57, 0x83, 0x1f, 0x19, 0xde, 0xbd, 0x45, 0x72, 0x71, 0x07, 0x2b, 0x4d, 0x27, 0x35, 0x82,
  0xd1, 0xae, 0xe1, 0x06, 0x80, 0xce, 0xde, 0x7e, 0x99, 0xe4, 0x55, 0xb2, 0xa3, 0xd8, 0xfd, 0xa2, 0x3a, 0x70, 0xe2, 0x64,
  0x13, 0xad, 0xce, 0x0b, 0x15, 0x2a, 0x24, 0x59, 0x46, 0x71, 0xd2, 0x02, 0x53, 0x90, 0xb8, 0x56, 0x90, 0xec, 0xee, 0xad,
  0x81, 0x06, 0xea, 0xaa, 0x39, 0x3c, 0x93, 0x36, 0x30, 0xbe, 0x82, 0xa1, 0x01, 0x29, 0x0d, 0xbc, 0x4f, 0x23, 0xfa, 0xdb,
  0xc0, 0x17, 0x06, 0xd3, 0x69, 0xcd, 0x5c, 0xd7, 0xf5, 0xc7, 0x86, 0x45, 0xbc, 0x74, 0x46, 0x3d, 0x53, 0xde, 0x6b, 0xb7,
  0x35, 0x47, 0x65, 0x4b, 0x78, 0x56, 0xdb, 0xe4, 0x59, 0xed, 0xf7, 0xee, 0x64, 0xc1, 0x57, 0x26, 0x59, 0x96, 0x2a, 0xd6,
  0x5e, 0xb8, 0x09, 0xfc, 0x86, 0x1f, 0x24, 0x5e, 0xb8, 0x88, 0xa5, 0x87, 0x77, 0xc8, 0x36, 0x9b, 0x22, 0x95, 0x36, 0x53,
  0xcb, 0x01, 0x4a, 0xfb, 0x18, 0x75, 0x6f, 0x53, 0x21, 0xde, 0x35, 0x3d, 0xff, 0xd2, 0x5b, 0xcd, 0xa0, 0x20, 0xd1, 0x02,
  0x93, 0x2c, 0xe5, 0x64, 0xe7, 0xf1, 0xe1, 0x36, 0x89, 0xac, 0xe7, 0x0d, 0x85, 0x51, 0xf4, 0xcf, 0x2a, 0x01, 0x61, 0x1e,
  0x5e, 0x07, 0x3e, 0x8b, 0x01, 0xcc, 0xdc, 0x49, 0xf3, 0x45, 0x8b, 0x21, 0xc2, 0xb1, 0x1e, 0xac, 0x2e, 0xab, 0xb1, 0x37,
  0x0f, 0x1a, 0x20, 0x88, 0x7b, 0x0d, 0x92, 0x5e, 0x84, 0x76, 0x5c, 0x13, 0x4c, 0xde, 0xe4, 0x72, 0xd5, 0x06, 0xb4, 0x52,
  0x67, 0x0b, 0x72, 0x2a, 0x55, 0x59, 0x1c, 0x3b, 0x4a, 0xfa, 0x22, 0x75, 0x5c, 0xea, 0xf8, 0xb0, 0x8e, 0xd5, 0x93, 0xf6,
  0xe5, 0x55, 0xbd, 0x87, 0xbe, 0x17, 0x4d, 0x62, 0x45, 0x99, 0x40, 0x93, 0x7c, 0x8b, 0xa0, 0x21, 0x43, 0x3d, 0x0c, 0xd7,
  0x9c, 0x2e, 0xae, 0x60, 0x3b, 0x9d, 0x5e, 0x56, 0x60, 0xe9, 0x9a, 0x02, 0x4b, 0x3b, 0xde, 0x31, 0x98, 0x9a, 0xf1, 0x05,
  0xc8, 0xec, 0x72, 0x1e, 0x6e, 0xf1, 0x84, 0x5b, 0x35, 0x59, 0x23, 0xeb, 0x79, 0x1c, 0x78, 0xed, 0x81, 0xeb, 0xc9, 0xaf,
  0x39, 0xa7, 0x65, 0xab, 0xd7, 0x9d, 0x77, 0x5c, 0x58, 0x16, 0x16, 0x73, 0xed, 0xca, 0xb4, 0x8d, 0xc6, 0x9e, 0x93, 0x4f,
  0x8c, 0xd4, 0x27, 0x15, 0xe4, 0x91, 0xc2, 0x71, 0x48, 0xb2, 0xc6, 0x2d, 0xbb, 0x3b, 0x0b, 0xf8, 0xd4, 0x7c, 0x23, 0x3c,
  0x27, 0xc5, 0x05, 0x1c, 0x2a, 0x84, 0xb6, 0xd2, 0x7a, 0x91, 0xc5, 0x95, 0xcd, 0xb1, 0x8a, 0x41, 0xee, 0x69, 0x4a, 0x96,
  0x73, 0xf8, 0xd7, 0x7a, 0x13, 0x25, 0x11, 0x14, 0xb2, 0xb4, 0x28, 0x8c, 0xf9, 0x26, 0xf9, 0x95, 0xaf, 0x4d, 0xd5, 0x83,
  0xec, 0x20, 0x16, 0x20, 0xf4, 0x04, 0x10, 0x38, 0x96, 0xc1, 0x44, 0x25, 0xc2, 0x83, 0x34, 0x5c, 0x41, 0x6c, 0x66, 0xd4,
  0x8b, 0xe4, 0x67, 0xdd, 0xf5, 0xed, 0x34, 0x51, 0x08, 0xc9, 0x58, 0xe9, 0x09, 0xb6, 0xaa, 0xd5, 0xbc, 0xf3, 0x9a, 0x69,
  0xa7, 0x80, 0xb0, 0x27, 0x78, 0xb6, 0xe6, 0x84, 0xd3, 0x07, 0x44, 0x13, 0xbb, 0x95, 0x4e, 0x2a, 0x45, 0x4b, 0xae, 0x39,
  0xd2, 0x42, 0x47, 0x8a, 0x14, 0x32, 0xb4, 0xf6, 0x40, 0x7b, 0xfa, 0xd4, 0x30, 0x39, 0x06, 0x88, 0x2b, 0xb7, 0x94, 0x71,
  0x5f, 0xf5, 0xd0, 0x57, 0xe2, 0x42, 0xe9, 0x1a, 0x1d, 0xb6, 0x3e, 0x4c, 0x0d, 0x05, 0x93, 0x2b, 0x69, 0x4b, 0x93, 0x2c,
  0xec, 0xa5, 0x28, 0xe8, 0x46, 0x2b, 0xaa, 0x09, 0x0c, 0x3d, 0x4d, 0x4f, 0xe9, 0x59, 0xe2, 0x34, 0x88, 0x87, 0xeb, 0x5e,
  0x5b, 0xc6, 0x11, 0x8c, 0x79, 0x02, 0x4c, 0xb8, 0x77, 0xfc, 0x4f, 0x8e, 0x0a, 0x25, 0x73, 0x3e, 0x05, 0xc1, 0x3a, 0x76,
  0x92, 0x8b, 0xc0, 0xf1, 0xd6, 0x30, 0xa1, 0x4b, 0x10, 0x3f, 0x63, 0x90, 0x76, 0xa7, 0xde, 0x86, 0xa4, 0xd1, 0x69, 0x84,
  0xbe, 0x02, 0x8c, 0x90, 0x08, 0x93, 0xd8, 0xd9, 0x04, 0xf1, 0x3a, 0x02, 0x42, 0x70, 0x19, 0x60, 0x8d, 0x65, 0x10, 0x37,
  0x9d, 0x7f, 0x3a, 0x16, 0xd1, 0x67, 0xb9, 0xd8, 0xa9, 0xb1, 0x08, 0x99, 0xea, 0xb9, 0xbd, 0x76, 0x3b, 0x0d, 0x99, 0x6a,
  0x4d, 0x41, 0x50, 0xf1, 0xf5, 0x90, 0xa9, 0x56, 0x7b, 0xd8, 0x49, 0x43, 0xa6, 0xba, 0xf3, 0xc1, 0x7c, 0xaa, 0x85, 0x4c,
  0x05, 0xd3, 0xce, 0x6c, 0xa8, 0x42, 0xa6, 0x5c, 0xbf, 0xe3, 0xf5, 0xda, 0xe3, 0x34, 0x16, 0xad, 0x7f, 0x32, 0x30, 0x02,
  0xa6, 0xdc, 0xfe, 0x70, 0xa6, 0x05, 0x4c, 0x75, 0x4e, 0x82, 0x93, 0xc1, 0x89, 0x1e, 0x30, 0x35, 0xed, 0xf8, 0xed, 0x69,
  0x1a, 0x30, 0x35, 0x9f, 0x0d, 0x7b, 0x03, 0x2d, 0x60, 0xaa, 0x7b, 0xd2, 0x19, 0xb8, 0xdd, 0xb1, 0x0c, 0x97, 0x9a, 0xf7,
  0xbb, 0x83, 0x59, 0x1a, 0x2e, 0xd5, 0xf5, 0x80, 0x80, 0x0e, 0x54, 0xb8, 0x94, 0x1c, 0x5b, 0x4a, 0x41, 0xbb, 0x56, 0x0a,
  0x5a, 0x1b, 0x37, 0x0c, 0xeb, 0xce, 0x3d, 0x8a, 0x82, 0x2a, 0x89, 0x17, 0x60, 0x37, 0x27, 0xac, 0x49, 0xe2, 0x0c, 0x7b,
  0xdf, 0x39, 0x2d, 0x90, 0xee, 0xdc, 0xf6, 0xb4, 0x3b, 0xc4, 0x5f, 0xad, 0x3e, 0x8e, 0xc1, 0xe9, 0x0c, 0xbf, 0xab, 0xab,
  0x98, 0x29, 0x67, 0x90, 0x86, 0x5c, 0x68, 0x86, 0x3b, 0x20, 0x9c, 0x29, 0xd6, 0xb4, 0x35, 0x31, 0x93, 0x7e, 0xcf, 0xd1,
  0x9c, 0x4e, 0xdc, 0x06, 0xe5, 0x9c, 0x4f, 0x81, 0x61, 0x16, 0x17, 0xef, 0x64, 0x80, 0x53, 0x73, 0x28, 0x5f, 0xe0, 0x3a,
  0xcc, 0x60, 0x27, 0xd1, 0xc0, 0xf5, 0x97, 0x7f, 0x01, 0x36, 0x26, 0xde, 0xd2, 0xee, 0xa3, 0x96, 0x61, 0xaf, 0x26, 0xe1,
  0x0c, 0xa6, 0xc6, 0x2a, 0xca, 0x32, 0xf4, 0xfd, 0x05, 0x50, 0x07, 0x1c, 0x16, 0x70, 0xfd, 0x79, 0x7c, 0x5b, 0xa4, 0x8b,
  0xb7, 0xc6, 0xca, 0xa2, 0x90, 0xf1, 0x08, 0xdb, 0xe2, 0xaf, 0x40, 0x2b, 0x2c, 0x88, 0xbf, 0x6a, 0x39, 0x6d, 0xa2, 0x66,
  0xa8, 0x76, 0xb4, 0x07, 0x43, 0x45, 0xd3, 0x74, 0xfb, 0x97, 0x12, 0x87, 0xb2, 0xf6, 0x25, 0xb2, 0xd3, 0x92, 0x26, 0x82,
  0x75, 0x1c, 0x11, 0x5b, 0x95, 0x91, 0x0e, 0x24, 0xab, 0x6e, 0xb7, 0x58, 0x50, 0x68, 0x91, 0xb5, 0xa0, 0xa5, 0x22, 0x47,
  0xfa, 0x5a, 0x0c, 0x4f, 0x3b, 0x17, 0xfa, 0xa2, 0x73, 0x3b, 0x5a, 0x58, 0xb5, 0x99, 0xa5, 0xb2, 0x29, 0x44, 0xd8, 0x07,
  0xee, 0xa0, 0xd3, 0xeb, 0xfa, 0x3b, 0x6b, 0x88, 0x53, 0x8f, 0x8c, 0x15, 0x59, 0xad, 0xb8, 0x4d, 0xfe, 0x7f, 0x3d, 0xc0,
  0x49, 0x70, 0xfe, 0x13, 0x7f, 0xda, 0x9f, 0xcd, 0x72, 0x71, 0x47, 0x7a, 0x28, 0x98, 0x16, 0xef, 0xd2, 0xed, 0x9b, 0x03,
  0xa5, 0x85, 0xd5, 0x04, 0x07, 0x7a, 0x16, 0x2d, 0xf7, 0x7b, 0xbe, 0x8b, 0xe6, 0x5d, 0x6c, 0xca, 0xd1, 0xb1, 0xcf, 0x88,
  0x2d, 0xc3, 0x06, 0x33, 0xf8, 0xd5, 0x37, 0x82, 0xa9, 0xb2, 0x8c, 0x4d, 0x67, 0x36, 0x3e, 0x69, 0xb2, 0x19, 0x23, 0xbd,
  0xb2, 0xb2, 0xf4, 0x06, 0xf5, 0x76, 0x07, 0x54, 0x86, 0xb6, 0x2b, 0xed, 0x8b, 0x46, 0x9c, 0x80, 0xb9, 0x64, 0xee, 0x89,
  0xbe, 0x64, 0x27, 0x4c, 0x4a, 0x49, 0xc4, 0x33, 0x97, 0x2f, 0x67, 0xd3, 0xd2, 0xcc, 0x83, 0x68, 0xae, 0x2a, 0x5d, 0xb1,
  0x0c, 0x75, 0x6e, 0xd9, 0xd6, 0xdc, 0x10, 0x6c, 0x08, 0xeb, 0x7c, 0x10, 0x8c, 0x69, 0xc2, 0x23, 0x66, 0x08, 0x24, 0xee,
  0xf4, 0x4c, 0x17, 0x31, 0x2f, 0x44, 0x26, 0x48, 0x81, 0xd9, 0xaf, 0x60, 0x83, 0xba, 0x1b, 0x66, 0x68, 0x5a, 0x0b, 0x70,
  0xe2, 0xe9, 0x7c, 0x5c, 0xbb, 0xcd, 0xf3, 0x44, 0x69, 0x30, 0x0f, 0xa6, 0x73, 0xbf, 0x17, 0x9c, 0x8c, 0x33, 0x3e, 0x63,
  0x5d, 0x39, 0xec, 0xb5, 0x5a, 0xe3, 0x83, 0xe2, 0x0e, 0xb5, 0x78, 0x04, 0x03, 0x47, 0x08, 0x8d, 0x55, 0x90, 0x55, 0xda,
  0xb5, 0x37, 0x9c, 0x0d, 0x82, 0x4e, 0x49, 0x14, 0x41, 0x4e, 0x25, 0x6e, 0xb5, 0x48, 0x25, 0x6e, 0x0d, 0x4e, 0xfa, 0xf3,
  0x2e, 0x10, 0xcf, 0xee, 0x60, 0x18, 0xcc, 0x6a, 0x85, 0x82, 0x6f, 0xcf, 0xf4, 0xb4, 0x03, 0xfa, 0x74, 0xda, 0x22, 0xaa,
  0xb0, 0x96, 0xe9, 0x56, 0x0c, 0x58, 0x77, 0x65, 0xc0, 0xf7, 0xc6, 0x1c, 0x58, 0x60, 0xb0, 0xd1, 0x15, 0x17, 0x83, 0x0a,
  0x91, 0x45, 0x88, 0xc4, 0x2a, 0xd0, 0x9f, 0x89, 0x75, 0x36, 0xd8, 0x56, 0x7c, 0x70, 0xa0, 0xa6, 0x6e, 0x7b, 0x4d, 0x2d,
  0xab, 0x36, 0xd7, 0x80, 0xb6, 0x1d, 0xf5, 0xe8, 0x8a, 0x8c, 0x0d, 0x56, 0x1f, 0x84, 0x23, 0x9f, 0x36, 0xd0, 0x8a, 0x9c,
  0x03, 0x6d, 0x0c, 0x9a, 0x44, 0x81, 0x59, 0x39, 0x2f, 0xcf, 0x19, 0x98, 0xdd, 0x6e, 0x0f, 0x30, 0x72, 0x39, 0x1f, 0x7b,
  0xa7, 0x77, 0x96, 0x89, 0xc0, 0xab, 0x54, 0x2c, 0xb6, 0x59, 0xde, 0x56, 0x5d, 0x61, 0x85, 0xed, 0x2a, 0x50, 0xb4, 0xf5,
  0x90, 0xbc, 0xbd, 0x11, 0x79, 0xb4, 0x54, 0x22, 0xc2, 0x51, 0xdb, 0x15, 0x6e, 0xb7, 0xa7, 0xed, 0x6f, 0x87, 0x63, 0xc9,
  0x15, 0x80, 0x3b, 0x42, 0xaf, 0x72, 0xdc, 0xb6, 0x6d, 0xbf, 0x5b, 0x36, 0xb4, 0x95, 0x36, 0x9a, 0xf6, 0x83, 0x6c, 0x80,
  0x53, 0x08, 0xf3, 0xf4, 0x68, 0xca, 0xfc, 0x4b, 0x08, 0xcf, 0x02, 0x34, 0x79, 0xa9, 0x1a, 0x94, 0xcd, 0x32, 0xbb, 0x3d,
  0xad, 0x5b, 0x1b, 0x26, 0x2f, 0x74, 0x9d, 0x8c, 0xad, 0x5e, 0x92, 0xbe, 0x46, 0x6a, 0xd7, 0x6f, 0x9e, 0xd8, 0x63, 0x0b,
  0xb1, 0x33, 0xa7, 0x39, 0xc3, 0x41, 0x4b, 0x8e, 0x68, 0xf1, 0x44, 0x28, 0x5a, 0x9a, 0x06, 0x23, 0x8a, 0xcd, 0x31, 0x38,
  0x99, 0x9d, 0xcc, 0xbd, 0xb1, 0x69, 0x10, 0xb1, 0x09, 0xa6, 0x22, 0x9e, 0x10, 0x90, 0xaa, 0xde, 0x6b, 0xf6, 0x31, 0xa2,
  0x90, 0x34, 0xe4, 0xd2, 0x18, 0x41, 0xe1, 0x99, 0xe5, 0xd6, 0x01, 0xcf, 0x43, 0x0f, 0xfe, 0x5d, 0x6d, 0x97, 0xc1, 0x26,
  0x9c, 0x8d, 0x12, 0x6f, 0x8a, 0x36, 0x0b, 0x7c, 0x8e, 0x99, 0xe6, 0xa5, 0x01, 0xed, 0x32, 0x1c, 0xfb, 0x41, 0xab, 0xe3,
  0xba, 0xee, 0x5c, 0x84, 0x18, 0x6a, 0x83, 0xcc, 0x5a, 0x9c, 0xfb, 0x18, 0xcf, 0xc4, 0x33, 0x0a, 0xfc, 0x79, 0x6f, 0x3e,
  0x13, 0xcb, 0xf0, 0x57, 0x00, 0x92, 0x9c, 0xaa, 0x37, 0x9b, 0x9d, 0xf8, 0x73, 0x7d, 0xaa, 0x3d, 0xd3, 0x9b, 0x23, 0x0c,
  0x4b, 0x50, 0x2d, 0xf1, 0xce, 0x49, 0x97, 0x2d, 0x42, 0x74, 0x0e, 0x63, 0x11, 0x71, 0x6c, 0xa9, 0x88, 0xc3, 0x41, 0xa7,
  0x1a, 0xfd, 0xa6, 0xd2, 0x56, 0x72, 0x4c, 0x87, 0x42, 0x46, 0x61, 0x02, 0xe5, 0x66, 0xca, 0x52, 0x34, 0x0b, 0x3c, 0xda,
  0x00, 0x65, 0x3a, 0xad, 0x8a, 0x3a, 0xb3, 0x45, 0x45, 0xb5, 0xf3, 0xfb, 0xc4, 0x50, 0xd8, 0x0e, 0x22, 0x64, 0xdd, 0x3d,
  0xa6, 0xcc, 0x0e, 0xd3, 0x6d, 0x14, 0x76, 0x3b, 0x03, 0xa0, 0xdf, 0x5e, 0xbb, 0xdd, 0x1e, 0x5a, 0xec, 0x79, 0x0f, 0xdc,
  0x59, 0xb7, 0xdf, 0x39, 0xc9, 0x2a, 0x3e, 0x2d, 0xdd, 0xf2, 0xd5, 0x97, 0x2c, 0x4d, 0xdb, 0xee, 0x27, 0xdd, 0x94, 0xab,
  0x74, 0x3b, 0x41, 0xaf, 0x1f, 0xe8, 0x73, 0x38, 0xd5, 0x99, 0x51, 0x47, 0x93, 0xdb, 0x3a, 0x16, 0x81, 0xe5, 0x44, 0xaf,
  0xd9, 0xbc, 0x0a, 0xe7, 0x61, 0x23, 0x09, 0x17, 0x0a, 0x23, 0xe6, 0xd3, 0x7e, 0x6f, 0xd8, 0x3f, 0x64, 0xb2, 0x9d, 0x56,
  0xbb, 0x05, 0x12, 0xcb, 0x83, 0x76, 0x0b, 0x14, 0xa5, 0xbe, 0xb2, 0x4f, 0x4a, 0x81, 0x6a, 0xde, 0x1e, 0x76, 0x07, 0x66,
  0x5f, 0xa4, 0x0f, 0xea, 0x9d, 0xb5, 0xbb, 0xd3, 0x3e, 0xf2, 0xb4, 0xfd, 0x9d, 0x01, 0x44, 0x67, 0xdd, 0x21, 0x29, 0x11,
  0xb3, 0x4e, 0x2b, 0xdb, 0x99, 0xdb, 0xeb, 0xce, 0x06, 0x7d, 0xa3, 0x33, 0x71, 0xd8, 0x42, 0xef, 0xcd, 0xeb, 0xcd, 0xfa,
  0x41, 0xf7, 0xa0, 0x75, 0x84, 0xd5, 0xeb, 0x78, 0xd0, 0xdb, 0x89, 0xeb, 0xb5, 0xbd, 0x5c, 0x6f, 0x73, 0x58, 0x81, 0x1e,
  0xf0, 0x83, 0x50, 0xf8, 0x4c, 0x6f, 0xb5, 0xd0, 0x99, 0xb1, 0xb0, 0xde, 0x18, 0xb1, 0xb2, 0x25, 0xe1, 0x4e, 0xbd, 0x7c,
  0x60, 0x2c, 0xd1, 0xde, 0x0c, 0x11, 0x91, 0x5b, 0x59, 0x1e, 0xf4, 0xc8, 0x47, 0xc7, 0xda, 0x65, 0x9b, 0x81, 0x22, 0x02,
  0x1a, 0x4f, 0x35, 0x03, 0xd3, 0x32, 0xd1, 0x56, 0x1b, 0x10, 0xb8, 0x53, 0x5a, 0x2f, 0xbc, 0x79, 0x99, 0x73, 0x08, 0x9d,
  0x42, 0xc3, 0x28, 0x45, 0x09, 0x49, 0x78, 0xf7, 0xa7, 0x81, 0xdf, 0xcd, 0xd0, 0xd1, 0x6c, 0xd0, 0xd0, 0x21, 0x9d, 0x17,
  0x75, 0x96, 0x22, 0x94, 0x53, 0x04, 0x0f, 0xb6, 0x8e, 0xa6, 0x66, 0x94, 0x34, 0x46, 0x52, 0x5f, 0xb3, 0x03, 0x8e, 0x0e,
  0xb4, 0x66, 0x6d, 0x94, 0xcf, 0x1f, 0xb4, 0x86, 0xee, 0x49, 0x7b, 0x60, 0xdf, 0xda, 0xa0, 0xe2, 0xb7, 0xac, 0xa6, 0xcc,
  0x9c, 0xcc, 0x96, 0xd5, 0xb4, 0xf1, 0xc0, 0x97, 0x22, 0x00, 0x43, 0x39, 0xc6, 0x4c, 0xac, 0xe3, 0x40, 0x8b, 0xc1, 0x2d,
  0xa5, 0x56, 0xae, 0xd6, 0x80, 0x29, 0xf7, 0x9d, 0xf4, 0x67, 0xdd, 0x60, 0xa0, 0x05, 0x4a, 0xe6, 0x8f, 0xe2, 0x58, 0xed,
  0x92, 0xfb, 0x03, 0x1e, 0xd9, 0xed, 0xaf, 0x05, 0x18, 0x1a, 0xf6, 0xdb, 0x7e, 0xa7, 0xd3, 0xf5, 0x94, 0x44, 0xee, 0xf9,
  0xed, 0xa0, 0x5f, 0x1e, 0xd1, 0xf7, 0xa0, 0x3d, 0x0b, 0x06, 0xfd, 0x81, 0xac, 0xd2, 0x6a, 0xb7, 0x3d, 0xb7, 0x5d, 0x1e,
  0xc7, 0xf7, 0xa0, 0xdf, 0xef, 0xce, 0x5c, 0xcd, 0x4a, 0x1c, 0xf4, 0xbc, 0x56, 0x69, 0xf4, 0xde, 0x83, 0xfe, 0xd0, 0xf5,
  0x3b, 0xed, 0xb4, 0x86, 0xdf, 0xf6, 0x4f, 0xac, 0x51, 0x7b, 0xc2, 0xe1, 0xa5, 0xf9, 0xbb, 0x70, 0xba, 0xe8, 0xf2, 0xcd,
  0x07, 0x1d, 0x49, 0xb7, 0xab, 0xdd, 0xd7, 0x8a, 0xb2, 0x5c, 0x04, 0x62, 0x24, 0xa2, 0xe4, 0x29, 0xff, 0x24, 0x83, 0x92,
  0x35, 0xe0, 0x55, 0x2b, 0xc9, 0xb8, 0x5e, 0x50, 0xb4, 0xb7, 0xcb, 0x35, 0x1a, 0x5f, 0x44, 0x9b, 0x64, 0xb6, 0x4d, 0xe2,
  0x9c, 0x15, 0xf6, 0x10, 0x31, 0xbc, 0x48, 0x12, 0x3c, 0xe4, 0xcc, 0x42, 0x01, 0x13, 0xde, 0x35, 0xe5, 0x90, 0x0e, 0x63,
  0xb9, 0x1d, 0x8b, 0xda, 0x77, 0xe8, 0xa6, 0x6b, 0xed, 0x61, 0xd7, 0x6d, 0x41, 0xe6, 0x5b, 0x6d, 0xaf, 0xe3, 0x23, 0x73,
  0x71, 0xfd, 0xf6, 0xac, 0x24, 0x48, 0x8f, 0xc8, 0x6a, 0x2e, 0x1a, 0x44, 0x4c, 0xc7, 0xe4, 0xbe, 0x9a, 0x70, 0x4f, 0xbf,
  0x15, 0xd3, 0x9e, 0x75, 0x50, 0xe7, 0x92, 0x95, 0x40, 0xa1, 0xdf, 0xc4, 0x49, 0x63, 0x76, 0x11, 0x2e, 0x24, 0xfb, 0x96,
  0xa7, 0x59, 0x7a, 0x83, 0x6e, 0xa0, 0x97, 0x5c, 0x25, 0x17, 0x5c, 0xae, 0xda, 0xae, 0x99, 0x45, 0x3b, 0x43, 0x7f, 0x3e,
  0xe8, 0x68, 0x45, 0x17, 0x9e, 0xbd, 0xcd, 0xf9, 0x7c, 0xda, 0xed, 0xb6, 0xd3, 0x82, 0xce, 0xb4, 0x9e, 0xfe, 0xb6, 0x1c,
  0x21, 0xd3, 0x4b, 0xea, 0x14, 0xa8, 0xab, 0x2f, 0xa3, 0xa8, 0xb8, 0xd7, 0x6f, 0x98, 0x13, 0x27, 0x55, 0x03, 0x4d, 0x6f,
  0x83, 0x62, 0x77, 0x81, 0xe2, 0x46, 0x92, 0x1a, 0xba, 0x50, 0xe6, 0x11, 0x06, 0x59, 0xc5, 0xba, 0x92, 0xca, 0x08, 0xa5,
  0x3e, 0x51, 0xe0, 0xab, 0x81, 0x55, 0xe5, 0x11, 0x57, 0x3a, 0xce, 0x4d, 0xbd, 0x38, 0x40, 0x04, 0x49, 0xa5, 0x45, 0x23,
  0x22, 0x51, 0xe1, 0x96, 0x24, 0x91, 0x56, 0xdf, 0x6c, 0xd6, 0x22, 0x65, 0x8c, 0x4c, 0x5b, 0x16, 0x75, 0x8c, 0x41, 0x2b,
  0xc2, 0x6e, 0x0f, 0x1b, 0x75, 0x95, 0xd6, 0x48, 0xbd, 0xf0, 0xf4, 0xd6, 0x2a, 0x3d, 0xe8, 0xb2, 0xb5, 0x9d, 0x5d, 0x9a,
  0x27, 0x79, 0x54, 0x83, 0xcd, 0x59, 0xb4, 0x04, 0xd8, 0x70, 0xec, 0xb0, 0x16, 0x6c, 0xe7, 0xb4, 0x6c, 0xee, 0xf4, 0x54,
  0xc8, 0x28, 0xe7, 0xc9, 0xa4, 0x9b, 0x08, 0x31, 0xa3, 0xc7, 0x21, 0xe8, 0xa9, 0x98, 0xaf, 0x02, 0xe4, 0x8b, 0xda, 0xd0,
  0x22, 0xeb, 0x34, 0x5a, 0x95, 0x23, 0x51, 0x82, 0x76, 0x65, 0x58, 0x98, 0x25, 0xda, 0x2d, 0x8b, 0xc1, 0xb9, 0x70, 0xb7,
  0x2c, 0x1f, 0x4b, 0x07, 0xe0, 0xc8, 0x50, 0xb6, 0xf4, 0x90, 0x41, 0x3e, 0x94, 0xe8, 0x41, 0x67, 0xda, 0x6b, 0xf5, 0x7b,
  0x87, 0xc7, 0x1e, 0x81, 0xcc, 0xec, 0x4f, 0xfb, 0x2d, 0x11, 0x30, 0x6b, 0x38, 0x3a, 0xdb, 0x41, 0xb7, 0x67, 0x8b, 0x4a,
  0xd4, 0x05, 0xd0, 0xf6, 0xb0, 0xd7, 0x1f, 0xf4, 0x8c, 0x58, 0x65, 0x9b, 0x58, 0x69, 0x12, 0xc5, 0xa1, 0x08, 0xd0, 0xb5,
  0x85, 0xbb, 0x16, 0xda, 0xa1, 0x82, 0x93, 0x60, 0xee, 0x82, 0x88, 0x3f, 0x1c, 0x74, 0x30, 0x6c, 0x3f, 0x33, 0x8c, 0x93,
  0x93, 0x7e, 0xd6, 0x22, 0xd5, 0x95, 0xf6, 0x22, 0xb6, 0x48, 0xb5, 0xd9, 0x22, 0x85, 0x41, 0x93, 0x6e, 0x61, 0x20, 0xad,
  0x3d, 0x3a, 0xd4, 0xec, 0xab, 0xe7, 0x0e, 0xbc, 0x93, 0x61, 0x51, 0x0c, 0xed, 0x83, 0x6e, 0x00, 0x8c, 0xc0, 0xd5, 0x18,
  0xf9, 0xc0, 0xe7, 0x2e, 0x0c, 0x3b, 0x9d, 0xab, 0xc5, 0xda, 0xd3, 0x6f, 0x81, 0x3a, 0x9b, 0x94, 0xa5, 0xa7, 0x21, 0xb4,
  0x3a, 0x74, 0x49, 0xa0, 0x92, 0x91, 0xd1, 0xf2, 0x40, 0x6c, 0x96, 0x1c, 0x15, 0x1d, 0x8b, 0x33, 0x63, 0xcd, 0xf7, 0xc4,
  0x7e, 0x28, 0xd8, 0x4e, 0x41, 0x35, 0xea, 0x16, 0x22, 0x42, 0xba, 0xa6, 0x06, 0x16, 0xb4, 0x0a, 0x63, 0xde, 0x65, 0x6c,
  0xae, 0x08, 0x04, 0x3e, 0x6c, 0x14, 0xba, 0xd8, 0x52, 0x10, 0x4c, 0xfb, 0xc0, 0x1d, 0x76, 0x66, 0xbd, 0x13, 0x63, 0x65,
  0x39, 0x66, 0xab, 0x04, 0xbb, 0x5c, 0xa5, 0x65, 0xcd, 0xbb, 0x2d, 0x62, 0xc3, 0xbd, 0xce, 0x30, 0xa7, 0x65, 0xf9, 0xdd,
  0x56, 0x6f, 0x60, 0x99, 0xb0, 0x6e, 0xfb, 0x35, 0x63, 0xd1, 0xb4, 0xfd, 0xe1, 0xf6, 0xfd, 0xd4, 0x61, 0x21, 0x45, 0x6e,
  0xc3, 0x25, 0x79, 0x48, 0x64, 0x52, 0x1f, 0x84, 0x0b, 0x50, 0x3a, 0xdb, 0x83, 0x9e, 0x3f, 0xec, 0xd4, 0xee, 0x10, 0xc2,
  0x63, 0x03, 0xa0, 0x19, 0x0c, 0x72, 0x97, 0x03, 0x28, 0xdc, 0x6d, 0x23, 0xde, 0x2e, 0x69, 0xe3, 0xe6, 0x8d, 0xee, 0x69,
  0x48, 0xbe, 0x08, 0x2e, 0x20, 0xe7, 0x51, 0x16, 0x43, 0xc7, 0x07, 0x48, 0xf0, 0x66, 0x57, 0x19, 0x6e, 0xd3, 0xb7, 0x28,
  0x93, 0xa6, 0xe4, 0xc9, 0xb5, 0xf3, 0x52, 0xaa, 0x21, 0x77, 0x72, 0xa0, 0x32, 0xd1, 0x23, 0x3a, 0x26, 0x27, 0x32, 0x2e,
  0xe8, 0xa3, 0xc5, 0xbd, 0xf8, 0x60, 0x05, 0xdc, 0x3a, 0xda, 0x7c, 0x6a, 0xc4, 0xa0, 0x0a, 0x43, 0xbd, 0xb8, 0xfe, 0xc0,
  0x9b, 0x46, 0xdb, 0x44, 0x34, 0x9f, 0xaf, 0xc5, 0xae, 0xf9, 0xb5, 0x77, 0x8e, 0x9a, 0xaa, 0x87, 0x5d, 0xdd, 0x1a, 0x9a,
  0x6e, 0x6a, 0x21, 0x63, 0xe7, 0x13, 0x71, 0xea, 0xc2, 0xe0, 0x4b, 0x4e, 0xa5, 0x60, 0x06, 0xb5, 0xd6, 0x3d, 0xf3, 0xd9,
  0x12, 0xdc, 0xfa, 0xa0, 0xdf, 0x99, 0xa1, 0x67, 0xd7, 0x12, 0xd7, 0xca, 0x0e, 0xe7, 0xf7, 0xc0, 0x1b, 0xbd, 0x06, 0xd9,
  0x92, 0x27, 0x47, 0x9c, 0x29, 0xe5, 0x83, 0xe9, 0x84, 0xa6, 0x97, 0xc2, 0x0b, 0x1d, 0xcc, 0xe7, 0x3d, 0x72, 0x2b, 0xa7,
  0x39, 0x51, 0x34, 0x17, 0x74, 0xe0, 0xcd, 0xdb, 0xf3, 0xa1, 0x4a, 0x88, 0x82, 0x56, 0x8b, 0x20, 0x75, 0x41, 0xc3, 0x26,
  0x98, 0x0e, 0x5b, 0xca, 0x05, 0x3d, 0x9b, 0xfa, 0xb3, 0x40, 0x77, 0x29, 0xfb, 0xbd, 0x79, 0x2f, 0x70, 0xcd, 0x7c, 0x26,
  0xad, 0xd9, 0x89, 0xf2, 0x31, 0x0f, 0x7b, 0xbd, 0x69, 0xcb, 0xd7, 0xd2, 0x99, 0xcc, 0x83, 0x0e, 0x35, 0xc0, 0xc9, 0x4e,
  0xfa, 0x6d, 0xd8, 0x27, 0x25, 0x93, 0x72, 0xb2, 0xce, 0x62, 0xe5, 0xf5, 0xdd, 0x15, 0xd7, 0xe1, 0xb0, 0x94, 0x92, 0xef,
  0x52, 0x78, 0x2c, 0x2b, 0x73, 0xf0, 0x99, 0x68, 0xcb, 0x36, 0x3d, 0xa8, 0x59, 0x47, 0xb7, 0x73, 0x18, 0x58, 0x53, 0x52,
  0x3d, 0x9b, 0xa4, 0xe0, 0x41, 0xeb, 0xa4, 0xdd, 0xed, 0x78, 0x36, 0x83, 0x81, 0x11, 0xe2, 0xb1, 0xa7, 0x49, 0x47, 0x19,
  0xa6, 0x35, 0x1a, 0x5c, 0x06, 0xc0, 0x0c, 0x75, 0x3e, 0x90, 0x7c, 0x95, 0xb4, 0xa8, 0x38, 0x79, 0x8e, 0x36, 0x94, 0x54,
  0xd2, 0x9c, 0x4f, 0xd2, 0x48, 0xed, 0xcd, 0xbb, 0xf3, 0x59, 0x59, 0x1d, 0xc3, 0x01, 0x75, 0xd7, 0x5a, 0xe4, 0x23, 0x32,
  0x94, 0xff, 0xe9, 0xb0, 0x7d, 0xd2, 0x3f, 0xb0, 0xa6, 0xf0, 0x6a, 0x6c, 0x54, 0x14, 0x42, 0x1a, 0x99, 0xa4, 0xc4, 0x6a,
  0xf6, 0xe6, 0xab, 0xd0, 0x24, 0x5d, 0xad, 0x69, 0xd9, 0x22, 0x99, 0x5c, 0xf7, 0x04, 0xcb, 0x53, 0x94, 0x8a, 0xd6, 0xcc,
  0xb0, 0xed, 0xe6, 0x03, 0x9c, 0xb8, 0x99, 0x76, 0x5b, 0x05, 0x02, 0x08, 0xa7, 0x7e, 0x9d, 0xdc, 0xc4, 0xd2, 0xb1, 0x94,
  0xfd, 0x7a, 0x6b, 0x66, 0x73, 0xe1, 0xf8, 0x1a, 0x8b, 0x1b, 0xde, 0xd5, 0x0e, 0x5a, 0x9b, 0xc2, 0xb2, 0xa1, 0x0c, 0x1d,
  0x1a, 0xf7, 0xc4, 0x27, 0x44, 0x2d, 0xa5, 0x4e, 0xcb, 0xe2, 0x3a, 0x76, 0x87, 0x1a, 0x46, 0xfa, 0x46, 0x49, 0x44, 0xfd,
  0x06, 0xaa, 0x33, 0x9b, 0x25, 0x79, 0xa3, 0x2c, 0x51, 0x67, 0x07, 0x98, 0x51, 0x44, 0x41, 0xdd, 0xd1, 0x91, 0x3b, 0xcd,
  0xab, 0x45, 0x6d, 0x18, 0xe6, 0x0c, 0x7d, 0xea, 0xe9, 0xac, 0xad, 0xe6, 0x01, 0x9a, 0x67, 0x49, 0x64, 0x9f, 0x19, 0xd4,
  0x26, 0xe2, 0x72, 0x4e, 0x5a, 0xd9, 0xe8, 0x8f, 0x3e, 0xf6, 0x54, 0xaa, 0xe2, 0x16, 0x44, 0x7e, 0xa0, 0x2e, 0x17, 0xce,
  0x84, 0x82, 0x4d, 0xba, 0xb6, 0x68, 0xd1, 0x8c, 0x3d, 0x29, 0x54, 0xb6, 0x4a, 0xd0, 0x47, 0x0f, 0xd7, 0xc8, 0xba, 0xce,
  0x30, 0xaa, 0xa2, 0x9e, 0x8f, 0xad, 0xe8, 0xb4, 0x4d, 0x57, 0x45, 0x1a, 0x2f, 0x47, 0xc3, 0x51, 0x21, 0x0d, 0x22, 0xd6,
  0x61, 0x23, 0xe2, 0x6a, 0xf2, 0xa7, 0x79, 0xfa, 0xc3, 0xcc, 0x11, 0x65, 0x79, 0x7c, 0x48, 0x0b, 0x47, 0x00, 0x65, 0x4e,
  0x4b, 0x48, 0xa0, 0x05, 0x3e, 0x28, 0x45, 0x89, 0x24, 0x8f, 0x94, 0x91, 0xb7, 0x7b, 0xdd, 0x7e, 0x2f, 0xc8, 0x85, 0xed,
  0xe9, 0xb6, 0x83, 0x38, 0xd9, 0x04, 0x80, 0x4f, 0xb6, 0xb0, 0x05, 0x8a, 0x6f, 0x4b, 0xa3, 0xf9, 0xba, 0x99, 0x01, 0xf6,
  0xb2, 0xb6, 0xdc, 0xe2, 0xe0, 0x89, 0x8e, 0x65, 0xad, 0x85, 0xa1, 0x2c, 0x7f, 0x88, 0x22, 0x0b, 0x79, 0x5b, 0xb4, 0x42,
  0xc6, 0xff, 0x6c, 0x0f, 0xbf, 0xe4, 0xc8, 0x55, 0x15, 0x44, 0x10, 0x07, 0xd0, 0x80, 0xaf, 0x4b, 0x9f, 0x2a, 0x5e, 0xc3,
  0x8c, 0x21, 0x30, 0x0e, 0x50, 0xa9, 0x13, 0x5c, 0x5d, 0xda, 0x12, 0x06, 0xfd, 0xd6, 0xe1, 0x64, 0x9f, 0x9e, 0xdd, 0xd9,
  0x4f, 0x6a, 0x56, 0xdd, 0xa0, 0xea, 0xe6, 0x90, 0xcc, 0x4a, 0xfa, 0xc4, 0x5d, 0xe9, 0xcc, 0x34, 0x3c, 0xe9, 0x7d, 0xc3,
  0xfb, 0xd6, 0xe6, 0xa3, 0x4f, 0x9a, 0xcb, 0x5a, 0x60, 0x9f, 0x86, 0x75, 0xe9, 0x09, 0xa4, 0x5e, 0x86, 0x66, 0x30, 0x46,
  0x0d, 0x85, 0x27, 0x54, 0xc7, 0x62, 0x53, 0xf6, 0x14, 0x9e, 0x10, 0x45, 0x51, 0x78, 0x8b, 0xe7, 0x3d, 0xcc, 0xfd, 0xb6,
  0x4a, 0x26, 0x63, 0xda, 0x5f, 0x74, 0x5f, 0x6e, 0xd6, 0xf8, 0x74, 0x80, 0xab, 0xd4, 0x9a, 0x40, 0xa2, 0x8c, 0xa4, 0xeb,
  0x6a, 0xe6, 0x30, 0x53, 0xd0, 0xf0, 0xb5, 0xe5, 0xa4, 0x7e, 0xad, 0x62, 0xbf, 0x5b, 0xc6, 0x0e, 0x32, 0x71, 0x1a, 0x05,
  0xec, 0xa0, 0x5e, 0x40, 0xcd, 0xeb, 0x87, 0x04, 0x34, 0xef, 0x31, 0x92, 0x1f, 0x0a, 0x2d, 0x19, 0x62, 0x60, 0x49, 0x62,
  0x64, 0x09, 0xd3, 0x1d, 0x18, 0x06, 0x41, 0xe3, 0xf0, 0x7b, 0xbf, 0xfd, 0xdd, 0xe1, 0x21, 0xce, 0x22, 0xce, 0x9d, 0xa1,
  0x5f, 0x98, 0xfd, 0xeb, 0xb0, 0x00, 0x67, 0x1d, 0xff, 0x7b, 0x05, 0xb8, 0xd7, 0xeb, 0xa5, 0xab, 0x95, 0xf3, 0xab, 0x75,
  0x53, 0x6d, 0xba, 0xd4, 0xff, 0x46, 0xf8, 0x9b, 0xcd, 0xb1, 0xd3, 0xca, 0x20, 0x9a, 0x8c, 0x88, 0x37, 0x35, 0xfb, 0x83,
  0xc5, 0x06, 0x2b, 0x23, 0x4e, 0x65, 0x90, 0x93, 0x62, 0x6e, 0xdc, 0xd1, 0x9a, 0x32, 0x4d, 0xd3, 0xd3, 0xdc, 0x24, 0x8a,
  0xcd, 0xde, 0x2d, 0x9b, 0x51, 0xdb, 0x04, 0xfa, 0xb7, 0x8f, 0xa4, 0xb7, 0xe7, 0x42, 0xd1, 0x3c, 0x7b, 0x6a, 0x47, 0x6b,
  0x9b, 0xc4, 0x51, 0x9f, 0x1d, 0xc3, 0x57, 0x97, 0xe1, 0x1a, 0x7a, 0x3e, 0x3a, 0xa9, 0x54, 0x50, 0x78, 0x33, 0x2a, 0xec,
  0xf1, 0x16, 0xa6, 0x7f, 0xd3, 0xe0, 0x20, 0xa0, 0xc2, 0x30, 0x58, 0x57, 0xb3, 0xb4, 0x69, 0x2b, 0xab, 0x8e, 0xd9, 0x36,
  0x5c, 0x4b, 0xbe, 0xb3, 0xd9, 0x22, 0x5c, 0xc3, 0x40, 0xa1, 0x3a, 0x05, 0x05, 0x55, 0x7b, 0x18, 0x1c, 0x6c, 0x49, 0xb5,
  0xa4, 0xa4, 0x91, 0x7b, 0xc5, 0x12, 0x68, 0xd7, 0x00, 0x86, 0xcd, 0x46, 0x6c, 0x7a, 0x0f, 0x64, 0xed, 0x81, 0x6e, 0xfa,
  0x16, 0x40, 0x2b, 0xb2, 0x83, 0x77, 0x73, 0xe0, 0xcd, 0x59, 0xbf, 0x4d, 0x03, 0x9c, 0x68, 0x48, 0xd8, 0x33, 0x50, 0xb3,
  0xfa, 0x64, 0x78, 0x35, 0x5a, 0x99, 0x43, 0xee, 0x6d, 0x93, 0x69, 0xb4, 0xcd, 0x84, 0x4c, 0x39, 0xc3, 0x90, 0xd6, 0x14,
  0xc0, 0xe6, 0x01, 0x92, 0xb8, 0xef, 0x29, 0xeb, 0xc6, 0xf7, 0x6c, 0xcb, 0xc8, 0x9c, 0x28, 0xae, 0x54, 0xca, 0x8e, 0x63,
  0xbb, 0x1a, 0x3d, 0xa6, 0xdf, 0x99, 0x90, 0xe8, 0x46, 0x37, 0x6b, 0x40, 0x1d, 0x98, 0x5e, 0x37, 0x23, 0x2a, 0x1b, 0xa4,
  0xd1, 0x4f, 0xa3, 0xed, 0x66, 0x51, 0x3d, 0x42, 0x4d, 0x6b, 0x14, 0x2e, 0xbd, 0xf3, 0xe0, 0x38, 0xbe, 0x3c, 0x7f, 0x7c,
  0xbd, 0x5c, 0xd4, 0xbf, 0xeb, 0x3c, 0x83, 0x9f, 0x0e, 0xfc, 0x5c, 0xc5, 0x93, 0xca, 0x45, 0x92, 0xac, 0x47, 0xc7, 0xc7,
  0x57, 0x57, 0x57, 0xcd, 0xab, 0x4e, 0x33, 0xda, 0x9c, 0x1f, 0xb7, 0x5b, 0xad, 0x16, 0x16, 0xae, 0x38, 0x68, 0x2f, 0xfa,
  0x3e, 0xba, 0x9e, 0x54, 0x50, 0xa8, 0x68, 0x77, 0xe1, 0x7f, 0x95, 0xef, 0x3a, 0x2f, 0xa0, 0x3e, 0x62, 0x8d, 0xe3, 0x4f,
  0x2a, 0xcb, 0x81, 0x33, 0x80, 0xad, 0x0f, 0xff, 0x6b, 0xf4, 0x9c, 0xee, 0x1f, 0x3b, 0x0b, 0xf8, 0xfb, 0x0a, 0xde, 0x0c,
  0x2a, 0x0e, 0x86, 0x8d, 0x4f, 0x2a, 0xb8, 0x1f, 0x2b, 0x0e, 0xc7, 0xc4, 0x4c, 0x2a, 0xd3, 0x05, 0x8c, 0x57, 0x3e, 0x32,
  0xf5, 0x9d, 0x54, 0xda, 0x95, 0x63, 0x6e, 0x14, 0xfb, 0x84, 0x5f, 0x47, 0x35, 0x87, 0x05, 0x92, 0x63, 0x84, 0x9c, 0x17,
  0xae, 0x9c, 0x15, 0x20, 0x0e, 0xb1, 0x86, 0x12, 0x51, 0xde, 0x3c, 0xd0, 0x01, 0x42, 0xa0, 0xe9, 0x80, 0xd1, 0x04, 0x27,
  0x12, 0xfd, 0xa6, 0x5e, 0x1c, 0xc6, 0x23, 0x3e, 0xbc, 0x62, 0xc8, 0x49, 0x19, 0x99, 0xb2, 0x8c, 0x5f, 0xe4, 0x35, 0xb8,
  0x56, 0x46, 0xec, 0xec, 0x14, 0xb1, 0x78, 0xb7, 0x54, 0x2f, 0x29, 0x53, 0xfe, 0x4d, 0x42, 0xa1, 0x29, 0xff, 0x96, 0xe6,
  0x3a, 0x7d, 0x1e, 0x68, 0x09, 0xb3, 0xd8, 0xe1, 0x31, 0x8f, 0x7f, 0x0e, 0x82, 0x35, 0x9d, 0xed, 0x58, 0x02, 0x3e, 0x6e,
  0xd7, 0x95, 0xd8, 0x99, 0x6f, 0x17, 0x8b, 0xba, 0x43, 0xb2, 0xdf, 0x22, 0xf0, 0x1d, 0x94, 0xc9, 0xd4, 0x79, 0x0f, 0x2f,
  0x71, 0x02, 0x40, 0xce, 0x1b, 0x67, 0xbd, 0x09, 0x10, 0x41, 0x1c, 0xea, 0x4c, 0x3b, 0xe2, 0xd1, 0x68, 0x88, 0xa2, 0x32,
  0x26, 0x6d, 0x20, 0x34, 0xb4, 0x9c, 0x82, 0x0d, 0xe8, 0x3d, 0xab, 0x8a, 0x5c, 0x8e, 0x7a, 0x95, 0x9a, 0xf3, 0x98, 0x4c,
  0xaa, 0x35, 0x53, 0x0f, 0x4b, 0x25, 0x31, 0xd5, 0x8c, 0xd8, 0x7c, 0x65, 0x81, 0xf7, 0x96, 0x68, 0x7b, 0x5b, 0x97, 0xdf,
  0x32, 0xf8, 0xfe, 0x9e, 0xd2, 0xac, 0xcc, 0x60, 0x71, 0x43, 0xb3, 0xd2, 0x7c, 0xaf, 0x65, 0xe3, 0x31, 0x03, 0x84, 0xbb,
  0xeb, 0x7d, 0x81, 0xdf, 0x9a, 0x02, 0x25, 0xe8, 0xbc, 0x7a, 0x73, 0x23, 0x45, 0x64, 0xa5, 0x7f, 0xed, 0x0d, 0x4a, 0xb7,
  0xa9, 0x5f, 0xf7, 0x04, 0xe6, 0xd7, 0x8b, 0xb5, 0x15, 0xa5, 0x63, 0xa9, 0x84, 0x12, 0x36, 0xfd, 0xf0, 0x80, 0xd4, 0x1d,
  0x5a, 0x02, 0xb1, 0x6c, 0x74, 0x82, 0x3a, 0x3d, 0x9d, 0x8f, 0x4e, 0xcf, 0xc6, 0xb3, 0x67, 0xb8, 0xf6, 0x3d, 0xab, 0x0a,
  0x26, 0xe4, 0xb9, 0x03, 0x02, 0xce, 0x73, 0xe4, 0x24, 0x9d, 0xe5, 0xdd, 0x23, 0xbb, 0xf5, 0x65, 0xd6, 0xc7, 0xdd, 0xb7,
  0x28, 0x6a, 0x1a, 0x34, 0x32, 0x82, 0xc2, 0x7e, 0xd5, 0xcd, 0x12, 0xc2, 0x9d, 0x4d, 0x4b, 0x52, 0xa8, 0xc9, 0xe5, 0x64,
  0xc0, 0x02, 0x79, 0xe5, 0x5e, 0xa1, 0xd5, 0xed, 0xb6, 0x80, 0x34, 0xfc, 0xa3, 0x6d, 0x68, 0x2a, 0xb8, 0xe5, 0xce, 0x66,
  0x20, 0x3a, 0x0a, 0x54, 0x46, 0xa0, 0xb0, 0x54, 0xcd, 0x72, 0x4c, 0xa8, 0xe8, 0x74, 0x90, 0x96, 0x38, 0x4f, 0x9b, 0xaf,
  0x65, 0x5a, 0x87, 0x93, 0x7f, 0xb5, 0xfc, 0x07, 0x5b, 0x7c, 0x8a, 0xd3, 0x18, 0x5b, 0x0e, 0x89, 0xe6, 0x4f, 0x57, 0x1e,
  0x04, 0xed, 0x76, 0x91, 0x25, 0x24, 0x87, 0x46, 0xda, 0x36, 0x32, 0x36, 0x4a, 0x3f, 0xbf, 0x4f, 0x4c, 0xcc, 0x4d, 0x0f,
  0x0b, 0xd9, 0xce, 0x09, 0xa4, 0x86, 0x97, 0x8c, 0xbd, 0x60, 0xdf, 0x61, 0xd7, 0x7e, 0xab, 0x04, 0x57, 0xdd, 0x7e, 0x37,
  0xc7, 0xc6, 0x46, 0x9c, 0xec, 0xcf, 0x69, 0xf7, 0xf7, 0x21, 0x4b, 0x4b, 0x21, 0x8b, 0x44, 0x74, 0xe9, 0xd8, 0x36, 0x49,
  0x44, 0x2b, 0xb3, 0x1f, 0x4c, 0xfc, 0x60, 0xed, 0xb6, 0x60, 0xb5, 0x75, 0xf8, 0x76, 0xda, 0xfb, 0x8c, 0x84, 0xfa, 0xfa,
  0x0e, 0xb5, 0xe5, 0x95, 0xc7, 0x5f, 0xcd, 0xb8, 0x9c, 0x61, 0x3e, 0x9c, 0x24, 0x43, 0xac, 0xec, 0x4b, 0xae, 0x29, 0x26,
  0x6a, 0xcb, 0xe6, 0x96, 0xbc, 0x6d, 0x5f, 0x72, 0x05, 0xa1, 0x5c, 0xbc, 0xc8, 0x1e, 0xbc, 0xe8, 0xe4, 0x10, 0xad, 0x08,
  0x47, 0x5c, 0x2d, 0xc6, 0x90, 0xa5, 0x8b, 0x62, 0x22, 0x98, 0xb5, 0xe3, 0x7d, 0x81, 0x27, 0xc3, 0xed, 0x66, 0x05, 0x18,
  0x19, 0xf5, 0xa4, 0x5b, 0x08, 0xd8, 0x57, 0x5b, 0x74, 0xfe, 0x81, 0x32, 0x0a, 0xe0, 0xe9, 0x87, 0x0e, 0x0b, 0x48, 0x96,
  0x04, 0x1b, 0x05, 0xd6, 0x2a, 0xb7, 0x24, 0x06, 0x48, 0x99, 0xdf, 0x94, 0xb1, 0xad, 0xbb, 0xf7, 0x60, 0xfb, 0x41, 0x46,
  0x29, 0x3e, 0xe8, 0xac, 0xc9, 0xc0, 0xda, 0x4c, 0x07, 0x56, 0xfa, 0x51, 0xea, 0xc4, 0xc8, 0xe1, 0x53, 0x41, 0xdc, 0xb7,
  0x5b, 0x62, 0x4c, 0x29, 0x36, 0x92, 0x58, 0x8e, 0x94, 0x5b, 0x14, 0xff, 0x8e, 0x18, 0xe8, 0x20, 0x1f, 0xf7, 0x2b, 0xed,
  0x8b, 0x1a, 0x56, 0x9d, 0x18, 0x9a, 0xb1, 0x19, 0x3f, 0x90, 0xd5, 0x8a, 0x2d, 0xd1, 0x05, 0x9d, 0x9c, 0x21, 0xb3, 0xc8,
  0xba, 0x45, 0xb6, 0xd2, 0x8c, 0x90, 0xc4, 0x21, 0x4f, 0x05, 0x3a, 0xed, 0x30, 0x1b, 0x43, 0x5c, 0xa0, 0xc9, 0x60, 0x3c,
  0xc7, 0xc0, 0x34, 0xa0, 0x62, 0x57, 0x25, 0xa1, 0xe4, 0x59, 0xec, 0xb2, 0x84, 0xf8, 0xb2, 0x28, 0x73, 0xb1, 0x41, 0x57,
  0x7a, 0xab, 0x24, 0x82, 0x2c, 0x13, 0x20, 0x66, 0x03, 0xd1, 0x40, 0x85, 0xe1, 0x38, 0x1c, 0xf5, 0x53, 0x17, 0x4f, 0x9c,
  0xbb, 0xcc, 0xd0, 0x03, 0xef, 0x6a, 0x92, 0x64, 0x33, 0x51, 0xce, 0xe2, 0xd5, 0xfa, 0xf6, 0xb9, 0x00, 0xf6, 0x9e, 0xf4,
  0xa7, 0xf6, 0xf6, 0x67, 0x0c, 0x30, 0x02, 0x32, 0x32, 0x49, 0x68, 0x72, 0x31, 0x1e, 0x4e, 0x93, 0x61, 0xc1, 0x41, 0x4c,
  0x59, 0xb3, 0xd7, 0xfd, 0x70, 0x89, 0x97, 0xd2, 0x78, 0xab, 0x44, 0x0f, 0x66, 0xb2, 0xaa, 0x1f, 0x25, 0xdc, 0x94, 0xba,
  0xa8, 0xa7, 0x59, 0xae, 0xea, 0xfb, 0x00, 0x67, 0x58, 0x7f, 0x19, 0x84, 0x69, 0x1d, 0xdc, 0x27, 0xfc, 0xc4, 0xcb, 0x2b,
  0x7e, 0x8b, 0x70, 0x2f, 0x7d, 0xad, 0x49, 0xb5, 0x7d, 0x85, 0x67, 0x31, 0xc5, 0xac, 0x1d, 0x44, 0xc3, 0x20, 0xa6, 0x5c,
  0x06, 0x66, 0x2a, 0x03, 0xb2, 0xa9, 0x82, 0x60, 0x10, 0x6d, 0xb1, 0x55, 0x07, 0xf4, 0xb5, 0x0b, 0x3d, 0x73, 0x81, 0x41,
  0xe7, 0xb0, 0x8d, 0x86, 0x96, 0x2b, 0x4a, 0x1c, 0x10, 0xfa, 0xf2, 0xf3, 0x4a, 0x2a, 0x02, 0x6b, 0xd6, 0x1f, 0x76, 0xdd,
  0x5d, 0xbe, 0x33, 0x0c, 0xa3, 0xff, 0xc7, 0x1c, 0x17, 0xba, 0x77, 0x50, 0xf8, 0x85, 0x65, 0xce, 0xe2, 0xee, 0x1e, 0x5d,
  0x33, 0x16, 0xb7, 0xf7, 0x98, 0xfd, 0x0c, 0x7a, 0xd3, 0x93, 0x93, 0xde, 0xee, 0x2e, 0xdd, 0x68, 0xb3, 0x15, 0x17, 0xfc,
  0x18, 0xc7, 0x33, 0xf9, 0x8e, 0x1f, 0xb3, 0x97, 0x79, 0xeb, 0xc4, 0x3b, 0xe9, 0xee, 0xee, 0x3d, 0xa0, 0xe3, 0x55, 0xde,
  0x6c, 0x16, 0xc4, 0xb1, 0x86, 0xe2, 0xe2, 0x05, 0x72, 0xd3, 0xf8, 0x0e, 0x09, 0xa5, 0xda, 0x85, 0xa1, 0xf5, 0x45, 0x98,
  0x7e, 0x48, 0xff, 0x87, 0xa0, 0x3c, 0x28, 0xa8, 0x80, 0x98, 0x7f, 0x01, 0x84, 0x66, 0x9b, 0xa5, 0x25, 0xfd, 0x2c, 0xd1,
  0x79, 0x80, 0x48, 0xb0, 0xc9, 0xa5, 0xf3, 0xd3, 0xab, 0x8a, 0x74, 0xac, 0xf9, 0x28, 0x32, 0xa3, 0xd0, 0xbe, 0x20, 0xab,
  0x7d, 0x19, 0x04, 0x71, 0xa3, 0xbd, 0x83, 0xfd, 0x34, 0x8f, 0xb6, 0x1b, 0x67, 0x41, 0x69, 0x3f, 0x60, 0x43, 0xc5, 0x14,
  0x69, 0x91, 0x5c, 0x6c, 0x82, 0xc0, 0xc1, 0x51, 0x90, 0xad, 0x08, 0x17, 0x1a, 0x3e, 0x6c, 0x02, 0xc7, 0x07, 0x18, 0xce,
  0x00, 0x06, 0x50, 0x24, 0x72, 0x88, 0xf8, 0x39, 0xf1, 0xcd, 0x6a, 0xa6, 0x6d, 0xb8, 0xdb, 0x3b, 0x9d, 0x7c, 0xd8, 0xdd,
  0xe1, 0xa0, 0x07, 0x46, 0x7e, 0xf9, 0x5b, 0xbc, 0x12, 0x48, 0x98, 0x72, 0x33, 0x3a, 0x8d, 0x79, 0xfc, 0x6a, 0x60, 0xcb,
  0xce, 0x95, 0x6b, 0x43, 0x66, 0x01, 0xcb, 0xc3, 0x9a, 0x29, 0x3b, 0x1d, 0x90, 0xd5, 0x09, 0x72, 0xf7, 0xa0, 0x63, 0xa9,
  0x45, 0x2c, 0x95, 0xe2, 0xc8, 0x93, 0x70, 0x1a, 0x2e, 0x40, 0x5a, 0xe3, 0xec, 0x81, 0x32, 0xad, 0x60, 0x5b, 0x1c, 0x34,
  0x33, 0x63, 0x59, 0x5a, 0xf6, 0x2c, 0x63, 0x96, 0x86, 0x60, 0x09, 0x8d, 0xc4, 0x5c, 0xd6, 0x32, 0x45, 0xb3, 0x2d, 0xb6,
  0x00, 0xfc, 0xa3, 0xe2, 0x4d, 0x4a, 0x14, 0xfb, 0x2f, 0x70, 0xcd, 0xde, 0x41, 0xa8, 0xdd, 0x3f, 0x9f, 0xa2, 0xf1, 0x49,
  0xce, 0x58, 0x36, 0xbe, 0x0c, 0x17, 0xb4, 0x23, 0x91, 0x2b, 0x72, 0xf5, 0x88, 0xcf, 0x73, 0x98, 0xd1, 0x76, 0xc3, 0x83,
  0xfa, 0x26, 0x94, 0xce, 0xd2, 0xae, 0x14, 0x16, 0x0c, 0xb1, 0x2a, 0x5b, 0x2c, 0xda, 0xae, 0xef, 0x94, 0x46, 0xd2, 0xd0,
  0x37, 0xbb, 0x99, 0x58, 0xda, 0x6e, 0x69, 0x5a, 0x49, 0x4b, 0xd7, 0xce, 0x45, 0x27, 0xbb, 0xa3, 0xf5, 0x23, 0xc9, 0xd6,
  0x89, 0x61, 0x35, 0x5d, 0xce, 0xcc, 0xf8, 0x93, 0x5a, 0x69, 0x1d, 0x0f, 0xf6, 0xe6, 0xd2, 0xc8, 0x43, 0x5c, 0x02, 0x61,
  0x01, 0x58, 0xbc, 0xa4, 0x87, 0x60, 0xeb, 0x88, 0x17, 0x94, 0xe0, 0x92, 0xdf, 0xa8, 0xdc, 0x96, 0x24, 0x9c, 0x5b, 0x6c,
  0xa2, 0x7a, 0xee, 0xf2, 0x82, 0xe8, 0x19, 0x23, 0xf2, 0x39, 0x33, 0x4c, 0x96, 0x93, 0xde, 0x27, 0x37, 0xeb, 0x60, 0x82,
  0xbb, 0xe9, 0x83, 0x6d, 0xe9, 0xd2, 0xd2, 0xf9, 0x13, 0x18, 0x16, 0x50, 0xbd, 0x67, 0xd3, 0xf2, 0x87, 0x8c, 0xdf, 0x55,
  0x7a, 0xa8, 0x81, 0x8e, 0x35, 0x08, 0x4b, 0xe2, 0x3b, 0x25, 0x70, 0xbc, 0x0b, 0x16, 0xda, 0x47, 0x50, 0x4c, 0x0a, 0x2c,
  0x1b, 0xe4, 0x20, 0x56, 0x5c, 0xb8, 0x77, 0xb3, 0xc8, 0x70, 0x40, 0x6b, 0xd2, 0x46, 0x6f, 0x05, 0xd4, 0x1d, 0xa8, 0x80,
  0xb9, 0xcf, 0x0c, 0xa5, 0x64, 0x77, 0xef, 0xc9, 0xb1, 0xb8, 0xed, 0xf1, 0xc9, 0xb1, 0xb8, 0xb4, 0x12, 0x03, 0x83, 0xf1,
  0x12, 0xc8, 0xcb, 0x73, 0xbc, 0x92, 0x29, 0x8e, 0x27, 0x47, 0x2a, 0xaf, 0xd2, 0x91, 0x83, 0xbc, 0x47, 0x78, 0x97, 0x27,
  0x47, 0xc9, 0x66, 0x1b, 0x1c, 0x09, 0xc7, 0xe0, 0x51, 0xb1, 0x63, 0xf0, 0xe8, 0xf4, 0x09, 0x56, 0x3e, 0xbd, 0xe7, 0x3c,
  0x89, 0x6f, 0x96, 0xd3, 0x68, 0xe1, 0x84, 0x3e, 0x34, 0xda, 0x40, 0x2a, 0x78, 0xa4, 0x9c, 0x86, 0x47, 0xca, 0x69, 0x08,
  0xe5, 0x85, 0xc3, 0xf0, 0x68, 0xd9, 0x41, 0x77, 0xe1, 0x49, 0x63, 0xe0, 0x9c, 0x38, 0x83, 0x4b, 0xd7, 0xbd, 0x68, 0xf4,
  0x2f, 0x1b, 0x83, 0x1f, 0x4f, 0x2e, 0x07, 0x3f, 0x76, 0xfe, 0x74, 0x74, 0x7c, 0x0a, 0xa3, 0xa7, 0x16, 0x73, 0x6d, 0xd3,
  0xcc, 0x0b, 0x1a, 0x47, 0x55, 0xc4, 0x81, 0x77, 0xbd, 0x23, 0xe7, 0x66, 0x72, 0xd4, 0x3f, 0x62, 0x8f, 0xd4, 0xe4, 0xc8,
  0xed, 0x1e, 0x39, 0xcc, 0xc5, 0xe1, 0x77, 0xfb, 0xc8, 0xd9, 0x40, 0x99, 0x0e, 0x76, 0x22, 0x47, 0xf3, 0x7a, 0xe8, 0xf4,
  0xff, 0xd8, 0xbe, 0x18, 0x5e, 0x76, 0xe1, 0x97, 0x0b, 0xff, 0xc0, 0xcf, 0x46, 0xf7, 0xb5, 0x7b, 0x02, 0x83, 0xbc, 0x68,
  0xbf, 0xa6, 0x7f, 0xfa, 0xf8, 0x4f, 0xf7, 0xa2, 0x5b, 0x36, 0x38, 0xbc, 0xc5, 0x13, 0x1d, 0x20, 0x7b, 0xc6, 0xd7, 0xa1,
  0xf1, 0xf5, 0xd2, 0xf1, 0x0d, 0xb5, 0xf1, 0xf5, 0x79, 0x7c, 0x6d, 0x63, 0x7c, 0x03, 0xa7, 0x7d, 0xd9, 0x7f, 0xed, 0xf2,
  0x3f, 0x00, 0x3a, 0xf7, 0xc2, 0x1d, 0xc2, 0x4b, 0xb7, 0x07, 0xa3, 0x73, 0x3b, 0xfc, 0x2f, 0x3c, 0x0e, 0x2f, 0xda, 0xa5,
  0xb0, 0x03, 0xb1, 0x74, 0xcf, 0xba, 0xbc, 0x6e, 0x3b, 0x43, 0xcf, 0xed, 0x3b, 0xf0, 0x3f, 0xa2, 0x91, 0x4e, 0x1b, 0xfe,
  0x79, 0xdd, 0x03, 0x62, 0xe9, 0xb9, 0x2e, 0xf4, 0x2b, 0xde, 0xba, 0x5d, 0x78, 0x0b, 0xa0, 0xea, 0x7b, 0x7d, 0x47, 0x96,
  0x1c, 0x3a, 0x2d, 0xec, 0x9c, 0xef, 0x2e, 0x73, 0x66, 0xd7, 0x0c, 0xeb, 0x19, 0xcc, 0xb4, 0xdd, 0x82, 0x39, 0xc1, 0x63,
  0xd9, 0xd8, 0xa4, 0x98, 0xbc, 0x0f, 0x6f, 0x00, 0x6b, 0xda, 0x4e, 0x97, 0x3a, 0xec, 0xc0, 0x7f, 0xe1, 0x6f, 0xc3, 0xc5,
  0x37, 0x8d, 0x36, 0xc0, 0xa6, 0xb3, 0x80, 0xbf, 0x0d, 0x7c, 0x82, 0xb7, 0x0d, 0xf8, 0x0a, 0xdf, 0x3a, 0x17, 0x8d, 0xee,
  0x02, 0x9f, 0xd4, 0xbb, 0x76, 0xa3, 0x8b, 0xa5, 0x2e, 0x1b, 0x9d, 0x57, 0xae, 0x73, 0xb2, 0xc0, 0x47, 0xd1, 0xd0, 0x9f,
  0x8e, 0x1c, 0x95, 0x0f, 0x00, 0x77, 0x81, 0x4c, 0x4b, 0xd9, 0x72, 0x1a, 0x6e, 0xcd, 0xa1, 0x4b, 0x5a, 0xab, 0xcd, 0x93,
  0x7e, 0xad, 0x60, 0x9e, 0xae, 0x4b, 0xf3, 0xec, 0x94, 0xcd, 0x13, 0x45, 0x98, 0x82, 0x39, 0xda, 0x5a, 0x6c, 0x53, 0x8b,
  0x27, 0x06, 0x32, 0xb8, 0x6d, 0x58, 0x08, 0x44, 0x87, 0xb6, 0x33, 0xb8, 0x68, 0xb6, 0x4a, 0xc1, 0x4a, 0x82, 0xc2, 0xd7,
  0xf7, 0xd7, 0xbf, 0xec, 0x2f, 0xa0, 0x56, 0x59, 0x4f, 0xd3, 0xc5, 0x36, 0x48, 0xf0, 0xce, 0xce, 0x7d, 0x2b, 0x58, 0x14,
  0x2a, 0x50, 0x3a, 0x8d, 0xf5, 0xf6, 0xa0, 0x3d, 0xdf, 0xb3, 0xef, 0xf9, 0xae, 0x6d, 0x4f, 0xc1, 0x76, 0x86, 0xfd, 0xee,
  0xf6, 0xe8, 0x1f, 0x78, 0x38, 0x11, 0x4f, 0xf4, 0xaf, 0x73, 0x72, 0x81, 0x7f, 0x61, 0x63, 0x11, 0x19, 0x38, 0xe1, 0x7f,
  0xe8, 0x11, 0x9f, 0x00, 0x1e, 0x3f, 0x9e, 0x94, 0xd2, 0x29, 0xbc, 0x1c, 0x38, 0x39, 0x88, 0x0e, 0x74, 0xec, 0x74, 0x60,
  0x68, 0xa7, 0x03, 0x6e, 0x9f, 0x28, 0x13, 0xa0, 0x40, 0xff, 0x8f, 0x03, 0xa4, 0x08, 0xf8, 0xa2, 0x14, 0x76, 0xf1, 0x76,
  0x75, 0x67, 0x04, 0xe8, 0xe6, 0x10, 0xee, 0xb2, 0x8d, 0xff, 0xb4, 0xe9, 0x5f, 0xa0, 0x06, 0x40, 0x6f, 0xda, 0xe2, 0xdf,
  0xae, 0xd3, 0xc5, 0x6d, 0xf7, 0xda, 0x45, 0xd2, 0x49, 0xbf, 0xa0, 0xf9, 0x16, 0x6c, 0x2b, 0x7a, 0xd5, 0xc7, 0x1f, 0x65,
  0xc3, 0xa3, 0xb8, 0xad, 0x7d, 0x38, 0x73, 0xe2, 0xf4, 0x00, 0x6b, 0x06, 0xc0, 0x2e, 0x4a, 0xa7, 0xba, 0x5e, 0x6c, 0xf7,
  0x11, 0x10, 0x9c, 0x45, 0xf7, 0xd2, 0xed, 0xc3, 0x20, 0x61, 0xf4, 0x40, 0x6d, 0x4b, 0x9b, 0xf3, 0x6e, 0xf6, 0x63, 0x33,
  0x34, 0xd4, 0x71, 0x86, 0x0d, 0xfc, 0x03, 0xf4, 0x83, 0xc2, 0x5d, 0x8e, 0xf4, 0x20, 0x9c, 0x23, 0x19, 0xf6, 0x72, 0x84,
  0xa2, 0x89, 0xd1, 0xdf, 0x93, 0x63, 0xe2, 0x9f, 0x4f, 0x90, 0x99, 0xc2, 0x93, 0x1f, 0x5e, 0x4a, 0xce, 0x4c, 0xde, 0x25,
  0x79, 0xe1, 0x74, 0xb0, 0x91, 0xaf, 0xd1, 0x21, 0x74, 0x84, 0xe3, 0xd4, 0x8a, 0x92, 0x3e, 0x8e, 0xac, 0x38, 0x7d, 0x85,
  0x2e, 0x21, 0x78, 0x93, 0xe1, 0xf4, 0x36, 0x26, 0x7f, 0xfa, 0x64, 0x1b, 0x07, 0x0e, 0xe8, 0xe6, 0xf3, 0xc9, 0xd1, 0x03,
  0xc9, 0x5d, 0x8f, 0xc5, 0x88, 0x60, 0x78, 0xe1, 0x25, 0x35, 0x7c, 0xfa, 0xe4, 0xc2, 0xd5, 0x2f, 0x94, 0x86, 0xa7, 0x27,
  0xe4, 0x4e, 0x22, 0x48, 0xcd, 0xaf, 0x8e, 0x4e, 0xff, 0xd8, 0x6a, 0xba, 0xce, 0x9b, 0x0e, 0x54, 0xc4, 0xd7, 0xb2, 0x2a,
  0xfd, 0x35, 0x87, 0x9b, 0xc6, 0x49, 0xe2, 0x08, 0x51, 0xd1, 0xc3, 0x26, 0xd0, 0x5a, 0xf0, 0x3c, 0xc2, 0xdb, 0xb2, 0xb9,
  0x94, 0x0f, 0xbf, 0x71, 0x14, 0xf0, 0x5d, 0x94, 0x12, 0x1f, 0xd0, 0xe0, 0x71, 0xa4, 0xaa, 0xbc, 0xc3, 0xa7, 0xd3, 0x67,
  0xa2, 0xc9, 0xd5, 0xf9, 0xdf, 0xff, 0xf6, 0xdf, 0x65, 0x25, 0x8f, 0x0a, 0x09, 0xfb, 0xc6, 0x8f, 0x04, 0xc5, 0x57, 0xa0,
  0x99, 0xaa, 0x1e, 0x74, 0xcb, 0xc7, 0x91, 0x80, 0x00, 0x8a, 0x3a, 0x31, 0xc8, 0x3a, 0xe7, 0x61, 0x72, 0xb1, 0x9d, 0xa2,
  0xba, 0x7b, 0x8c, 0xd6, 0xed, 0x24, 0x3a, 0x9e, 0xe1, 0xdc, 0xd1, 0x2e, 0x01, 0x1c, 0x02, 0x04, 0x62, 0xbc, 0xf5, 0xfb,
  0xe3, 0x74, 0xe1, 0x61, 0xd5, 0x4d, 0xb0, 0xc0, 0xa5, 0x8d, 0xd6, 0xc1, 0x0a, 0x16, 0x6a, 0x15, 0xd1, 0xe5, 0xd0, 0x1b,
  0xbc, 0xb9, 0xfb, 0x0f, 0x61, 0xf2, 0xe3, 0x76, 0xfa, 0xe4, 0xd8, 0x93, 0x80, 0x60, 0x51, 0x2c, 0xd8, 0x9c, 0xde, 0x03,
  0x31, 0x4c, 0x04, 0x8b, 0x8a, 0xe1, 0xa0, 0xc1, 0x57, 0x2c, 0x10, 0x39, 0x31, 0x26, 0x47, 0xcf, 0x18, 0x87, 0x9c, 0xef,
  0x25, 0x61, 0x15, 0xd6, 0x11, 0x94, 0x16, 0x09, 0x07, 0xb4, 0xe5, 0x95, 0x6e, 0x9b, 0x0c, 0xb6, 0xba, 0x20, 0xa8, 0xc1,
  0x9e, 0x05, 0xf6, 0xbb, 0xde, 0x04, 0x71, 0xb0, 0xb9, 0x0c, 0x9e, 0xc6, 0x6b, 0xe8, 0xf7, 0x0d, 0xaa, 0xd0, 0x93, 0xa3,
  0xeb, 0xd7, 0xa1, 0xff, 0xaf, 0xaf, 0x3d, 0x50, 0x1e, 0x16, 0xe1, 0x2c, 0xb0, 0xa2, 0xc7, 0x3d, 0xc7, 0x61, 0x19, 0xef,
  0x09, 0x1b, 0x18, 0xff, 0x20, 0xec, 0x8b, 0x04, 0xdc, 0xf8, 0x13, 0x6c, 0x8f, 0xeb, 0x36, 0xf4, 0x05, 0x84, 0xac, 0x8d,
  0x0c, 0x1e, 0xd6, 0x0a, 0x8d, 0xdc, 0xf8, 0x87, 0x8d, 0x72, 0x80, 0x55, 0x6e, 0xab, 0xdd, 0xed, 0x12, 0x4f, 0xa4, 0x6f,
  0x6c, 0x2f, 0x9a, 0x1c, 0x35, 0xfb, 0xbd, 0x23, 0xb3, 0x60, 0x67, 0xd8, 0xe9, 0x74, 0xfd, 0x5c, 0x41, 0x37, 0x53, 0xec,
  0x64, 0xda, 0x77, 0x7b, 0x33, 0x42, 0x52, 0x73, 0x4c, 0xd6, 0x31, 0xce, 0x01, 0xde, 0xd6, 0x61, 0x71, 0x04, 0x4f, 0x7e,
  0x58, 0xdd, 0x23, 0x6b, 0x39, 0x7e, 0x29, 0xbc, 0x62, 0x38, 0x63, 0x5b, 0xff, 0x40, 0x15, 0x40, 0x51, 0x63, 0x8c, 0xbe,
  0x0a, 0x57, 0x7e, 0x74, 0x15, 0xdb, 0x19, 0x12, 0xae, 0x08, 0x97, 0xfd, 0x75, 0x15, 0x26, 0xb0, 0x80, 0xb0, 0x0b, 0x37,
  0x6f, 0xd1, 0x85, 0xf2, 0xf3, 0xea, 0xd7, 0x38, 0x28, 0xe1, 0x11, 0x1d, 0xad, 0x95, 0x66, 0x4f, 0xd2, 0x9b, 0x07, 0x01,
  0x48, 0x62, 0xfd, 0xe9, 0x91, 0xa3, 0x06, 0x88, 0xe0, 0xc5, 0x21, 0x8a, 0x6e, 0x4e, 0x05, 0xa9, 0xc1, 0xf5, 0xa4, 0xa6,
  0xe5, 0xa8, 0x00, 0x43, 0xd2, 0x16, 0x09, 0x55, 0xb8, 0x45, 0x0c, 0x1a, 0x7c, 0x00, 0x0b, 0x5c, 0x33, 0x38, 0x01, 0xa0,
  0x54, 0xef, 0xc4, 0xe9, 0x63, 0x68, 0x04, 0x50, 0x7b, 0xe4, 0x96, 0x3d, 0xf8, 0xff, 0x10, 0xfe, 0xdf, 0xe9, 0x00, 0x61,
  0x84, 0x77, 0x5d, 0x10, 0xa4, 0x5a, 0x28, 0x2f, 0xc2, 0xbf, 0x58, 0xae, 0x7d, 0xe2, 0x74, 0xdb, 0x20, 0x4f, 0xb6, 0x80,
  0xec, 0x0e, 0xe0, 0x3d, 0x08, 0x96, 0xbd, 0x36, 0x0a, 0x00, 0xf0, 0x2f, 0xd5, 0x83, 0xe6, 0xb0, 0x5e, 0x7b, 0xe8, 0x0c,
  0xb0, 0x5e, 0x17, 0x48, 0x3c, 0x96, 0x6b, 0xf7, 0x9c, 0x61, 0x17, 0xf8, 0x4e, 0xb7, 0xe7, 0x9c, 0x00, 0x12, 0xbb, 0x9d,
  0xbe, 0x73, 0x42, 0xfd, 0xf6, 0x19, 0xab, 0xdd, 0xce, 0xe0, 0x8f, 0x30, 0xdc, 0x1f, 0x5b, 0x8a, 0xe6, 0x62, 0x3e, 0x91,
  0x59, 0x1b, 0x11, 0x03, 0x27, 0xa9, 0x0f, 0xf9, 0x04, 0xc4, 0xe5, 0x6e, 0xeb, 0xb2, 0xd1, 0xee, 0x5d, 0x74, 0xda, 0x97,
  0xf0, 0xb7, 0xdb, 0x03, 0x26, 0x0a, 0x32, 0xf3, 0xe0, 0x12, 0xfe, 0x76, 0xe0, 0x4b, 0xa7, 0x7b, 0xd1, 0xee, 0x5e, 0xe2,
  0xdf, 0x93, 0xcb, 0x46, 0x0f, 0x0a, 0xb4, 0x2e, 0xe1, 0x2f, 0x68, 0x02, 0x8d, 0xce, 0x09, 0x16, 0xe3, 0xbf, 0x8d, 0x7e,
  0xe7, 0xa2, 0xd3, 0xbb, 0x84, 0xbf, 0x6d, 0xfc, 0x32, 0xb8, 0xe8, 0x74, 0x2e, 0xe1, 0x6f, 0x1b, 0x44, 0xc9, 0x1e, 0xe8,
  0x09, 0xbd, 0x4b, 0xf8, 0xdb, 0x69, 0x53, 0x6b, 0xdd, 0x36, 0xb5, 0x06, 0x75, 0x06, 0x2e, 0x16, 0xc3, 0xbf, 0xd0, 0x4f,
  0x77, 0x88, 0x3d, 0xe0, 0x5f, 0x28, 0xd6, 0x6d, 0x61, 0x6b, 0xf8, 0x17, 0x5a, 0xeb, 0xf5, 0xb1, 0x18, 0xfc, 0x6d, 0x77,
  0xa0, 0x01, 0x1a, 0x5b, 0x87, 0x07, 0xda, 0x1e, 0x5e, 0x74, 0x81, 0xed, 0x0e, 0x79, 0xd4, 0x2e, 0x8e, 0x0d, 0xff, 0x62,
  0x3f, 0xad, 0x8b, 0x6e, 0xff, 0xb2, 0x7b, 0x62, 0x00, 0xa1, 0xef, 0x76, 0xdb, 0xee, 0xff, 0xde, 0x40, 0x20, 0xdc, 0x15,
  0xfb, 0xaf, 0x96, 0x01, 0xc5, 0x72, 0x40, 0x18, 0x3b, 0x70, 0xfa, 0x0d, 0x17, 0xd4, 0xb9, 0xde, 0x02, 0xf0, 0xc9, 0xed,
  0xbe, 0x1e, 0xf4, 0x01, 0x7f, 0x61, 0x1c, 0xa0, 0x55, 0xf5, 0x00, 0x03, 0x01, 0x56, 0xa0, 0x50, 0x41, 0xc9, 0x21, 0xc9,
  0x08, 0x0a, 0xb8, 0x43, 0x4c, 0x88, 0x9f, 0x32, 0xf4, 0x07, 0xc3, 0xd6, 0x89, 0x7b, 0x12, 0x1c, 0x99, 0x91, 0xac, 0xb4,
  0x31, 0x4d, 0x0d, 0x01, 0x9a, 0x17, 0xaa, 0x50, 0x8f, 0x55, 0x21, 0x6d, 0xeb, 0xce, 0xe7, 0x83, 0x93, 0x81, 0x6b, 0x0a,
  0x5c, 0x03, 0x5c, 0xb0, 0x93, 0x7f, 0x73, 0x87, 0xad, 0x06, 0xa8, 0x5a, 0xb4, 0x91, 0x92, 0x6e, 0xbb, 0xd5, 0xe8, 0xca,
  0x5a, 0x24, 0x4a, 0xa4, 0xe3, 0xf0, 0xa7, 0x40, 0x15, 0x87, 0xb9, 0x71, 0xe8, 0xf4, 0x80, 0x86, 0x74, 0xf8, 0xd6, 0x47,
  0xba, 0xc9, 0xb0, 0x13, 0xd2, 0x89, 0xc9, 0xc4, 0xf5, 0x2c, 0x8f, 0xa6, 0xec, 0x21, 0xe2, 0x15, 0x98, 0x47, 0x33, 0xaf,
  0x6a, 0x34, 0x46, 0xf4, 0xbf, 0x54, 0x9e, 0x50, 0x6c, 0x1e, 0xb4, 0x2b, 0x2e, 0x49, 0xbf, 0x4e, 0x5f, 0x45, 0xe4, 0xaf,
  0x24, 0x1e, 0x47, 0xbc, 0x3c, 0x5b, 0x41, 0x05, 0x34, 0x70, 0x2d, 0x7c, 0xfc, 0x13, 0x3e, 0x9d, 0x3e, 0xdd, 0xc2, 0xdc,
  0xbd, 0x45, 0xe8, 0x1d, 0x7f, 0xbf, 0x09, 0xe3, 0xa9, 0xb7, 0x0a, 0x8a, 0x45, 0x10, 0x3d, 0x16, 0xe8, 0x88, 0xc5, 0x1a,
  0xcd, 0xf3, 0x50, 0x7f, 0x32, 0xdd, 0x9c, 0x02, 0x63, 0xbe, 0x41, 0x2f, 0x86, 0xb4, 0xee, 0x2b, 0x06, 0x2e, 0xd8, 0xb6,
  0x85, 0x83, 0x93, 0x11, 0xd7, 0x64, 0xe1, 0xe4, 0x75, 0xf4, 0x83, 0x4b, 0xe0, 0xae, 0x0e, 0xfb, 0xbe, 0xb3, 0xc2, 0x5b,
  0x6a, 0x64, 0xfe, 0x22, 0x79, 0x8d, 0xd5, 0x3b, 0x25, 0xaf, 0x69, 0x0d, 0xab, 0x2c, 0x79, 0xe6, 0xea, 0x68, 0x61, 0x12,
  0x47, 0xa7, 0xef, 0x00, 0xca, 0xce, 0x5b, 0x98, 0xe6, 0x2c, 0xc8, 0x43, 0x5a, 0x0b, 0x9a, 0x48, 0x61, 0xfd, 0x8c, 0xfa,
  0x3b, 0x7d, 0x86, 0x39, 0x56, 0xa4, 0xb8, 0x95, 0xad, 0x88, 0x11, 0x15, 0x5c, 0x23, 0xa6, 0xa6, 0x51, 0x62, 0x3c, 0x3a,
  0xfd, 0xcd, 0x0b, 0x51, 0x40, 0x73, 0x40, 0xb5, 0x76, 0x68, 0xd4, 0xfa, 0xf2, 0xd8, 0x16, 0x49, 0x3b, 0xf6, 0x9d, 0x1e,
  0x78, 0xf9, 0x22, 0x20, 0xa5, 0x9a, 0xe9, 0x97, 0x02, 0xea, 0x37, 0x42, 0x8e, 0xea, 0xf7, 0xaf, 0x5e, 0xd4, 0x0e, 0x04,
  0x14, 0xd5, 0x38, 0x3a, 0xfd, 0x09, 0x5d, 0xd2, 0x37, 0x98, 0x7e, 0xa2, 0x00, 0x4e, 0x9a, 0x08, 0x4c, 0xed, 0xc8, 0x7a,
  0x18, 0x59, 0x6d, 0x13, 0x7f, 0x33, 0x07, 0x41, 0x8e, 0x32, 0x35, 0xdf, 0x6e, 0xa7, 0xd8, 0xa9, 0x13, 0x6f, 0xc9, 0xd7,
  0x38, 0xdf, 0x2e, 0x9c, 0xab, 0x4d, 0x98, 0x04, 0xce, 0x4d, 0x90, 0xc8, 0xe6, 0x4a, 0x16, 0x2c, 0x6d, 0xe8, 0x7b, 0x12,
  0x1b, 0x00, 0x26, 0xe2, 0xc7, 0xc8, 0xd9, 0xae, 0xbc, 0x4b, 0x2f, 0x5c, 0xe0, 0xa5, 0x60, 0xce, 0xff, 0xfc, 0x1f, 0x0e,
  0x83, 0xc4, 0xbd, 0xcb, 0x2a, 0xca, 0x9c, 0x97, 0x8e, 0x72, 0xf0, 0x1e, 0x09, 0x49, 0x69, 0x1e, 0xbe, 0xa5, 0xdd, 0xf1,
  0xee, 0x4b, 0x97, 0x98, 0x2c, 0x5b, 0x5f, 0xbc, 0xba, 0xe1, 0xdf, 0xff, 0xf6, 0x5f, 0x7f, 0x08, 0x0f, 0x5d, 0x59, 0xec,
  0xea, 0xd0, 0x1d, 0xc0, 0x00, 0x85, 0x1a, 0x2f, 0xd7, 0x47, 0xa7, 0x7f, 0xff, 0xdb, 0xbf, 0xdf, 0x01, 0x5c, 0x9a, 0xcf,
  0xe9, 0xcb, 0x48, 0xc3, 0x7a, 0xfb, 0xc5, 0x10, 0x79, 0x4b, 0x7d, 0x1f, 0x00, 0x10, 0x7a, 0xc1, 0xa5, 0xef, 0x06, 0x93,
  0x5f, 0xd7, 0xcc, 0x1a, 0xf8, 0xdf, 0x91, 0x63, 0x87, 0x8d, 0x41, 0x6e, 0x01, 0xff, 0x64, 0x63, 0xf0, 0x33, 0xa3, 0x2b,
  0xa9, 0x0b, 0x2a, 0x44, 0x05, 0x26, 0xb4, 0x9c, 0x4c, 0x44, 0xab, 0x85, 0x71, 0x89, 0x9c, 0x4d, 0xe7, 0xc8, 0xa1, 0x30,
  0x04, 0x54, 0x97, 0x60, 0x5d, 0xc9, 0x60, 0x4d, 0x0d, 0x0a, 0xcd, 0x1d, 0xf4, 0x43, 0xef, 0xfc, 0xcb, 0x00, 0x4f, 0x8d,
  0x29, 0xc8, 0xd3, 0x9e, 0xfb, 0x59, 0xb8, 0xbd, 0xd5, 0x16, 0xe4, 0x81, 0x15, 0x0d, 0xd1, 0x18, 0x1b, 0xab, 0xe4, 0xdf,
  0x40, 0x99, 0xa7, 0xae, 0x69, 0xdb, 0x06, 0xf1, 0x97, 0x0c, 0x44, 0xb2, 0xc2, 0xf8, 0xcb, 0xd0, 0x51, 0x9a, 0xc6, 0xcd,
  0xf1, 0xbc, 0x95, 0x8d, 0x7e, 0xc9, 0x88, 0x44, 0x3c, 0xcf, 0x37, 0xa0, 0x18, 0xd4, 0xf7, 0x4f, 0xdc, 0xdc, 0x17, 0xc1,
  0x46, 0x5a, 0xaf, 0xbf, 0x64, 0x28, 0xaa, 0x72, 0x06, 0x34, 0xe2, 0xf5, 0x97, 0x8c, 0x47, 0x26, 0x3d, 0xfa, 0xb2, 0xa5,
  0x22, 0xd3, 0xa5, 0x39, 0x98, 0xe7, 0xa1, 0x77, 0xbe, 0x8a, 0xe2, 0x24, 0x9c, 0x7d, 0xd9, 0x78, 0x30, 0x83, 0xd0, 0x17,
  0x0d, 0x86, 0xec, 0xe5, 0xe6, 0x58, 0x9e, 0x62, 0x63, 0x96, 0x51, 0x68, 0xd4, 0x26, 0x8d, 0x2e, 0x86, 0xf6, 0xcc, 0xd1,
  0xe9, 0x81, 0xbd, 0x42, 0x48, 0xc5, 0x37, 0xef, 0xc4, 0x8b, 0x68, 0x35, 0x5b, 0x00, 0x7d, 0x82, 0xb7, 0xf4, 0xe2, 0x1d,
  0x7e, 0xab, 0xd6, 0x4c, 0x6a, 0xf3, 0x96, 0xf3, 0xcd, 0x25, 0x91, 0x43, 0xe1, 0x4b, 0x1c, 0x22, 0x26, 0x8a, 0xa0, 0xa1,
  0x25, 0x0e, 0xc8, 0xf0, 0xb0, 0x88, 0xbf, 0x8c, 0x80, 0xa0, 0xc1, 0xd6, 0x98, 0xb1, 0x39, 0x74, 0x29, 0xbc, 0xe1, 0x83,
  0xd5, 0x42, 0x96, 0x06, 0x1d, 0xdb, 0x3b, 0xcb, 0x40, 0x4e, 0xd1, 0x5a, 0x00, 0x1a, 0xd2, 0xd9, 0x25, 0x1e, 0xb5, 0x43,
  0xb8, 0xe0, 0x8f, 0x54, 0xc6, 0xcf, 0xc9, 0xbb, 0x14, 0xc7, 0x23, 0x89, 0x29, 0x96, 0xc7, 0x17, 0x4c, 0xfd, 0x32, 0xab,
  0x81, 0x2e, 0x4d, 0x47, 0x45, 0x49, 0xb0, 0x51, 0xc9, 0xc3, 0x53, 0x8d, 0xa8, 0x1d, 0x09, 0x85, 0x82, 0xc2, 0x67, 0x55,
  0xf4, 0x84, 0xa3, 0x1d, 0xef, 0x34, 0xf9, 0x94, 0x8c, 0xa0, 0x85, 0xb7, 0x17, 0xed, 0xaf, 0xa7, 0x8a, 0x2c, 0xc6, 0x08,
  0xa3, 0x66, 0xdb, 0x04, 0xa4, 0x16, 0xad, 0x2a, 0x04, 0x15, 0x2c, 0xfc, 0x0b, 0x3e, 0x9a, 0x02, 0x9a, 0x60, 0xe4, 0x8e,
  0x31, 0x69, 0xfd, 0xf4, 0xaa, 0x90, 0x1e, 0x60, 0x7a, 0x2c, 0xa5, 0x09, 0x55, 0x80, 0x1a, 0x29, 0x94, 0x0f, 0xd3, 0x43,
  0xad, 0x99, 0xea, 0xcf, 0x49, 0x55, 0xb2, 0x49, 0x79, 0xa0, 0xde, 0x61, 0x54, 0x80, 0xaf, 0x8d, 0xc8, 0x44, 0x7e, 0xe4,
  0x7f, 0x22, 0x11, 0xa1, 0x33, 0x65, 0xd7, 0x90, 0x6c, 0x5a, 0x3f, 0xb2, 0xaa, 0x6d, 0x03, 0x1c, 0x9d, 0xb2, 0x40, 0x56,
  0x93, 0x8b, 0x10, 0x34, 0xea, 0x53, 0xe2, 0xb4, 0x6f, 0x29, 0xd4, 0x32, 0xf0, 0x59, 0x14, 0xd4, 0x36, 0xa2, 0x09, 0x87,
  0x34, 0x48, 0x59, 0xa4, 0xbc, 0x3c, 0x12, 0x16, 0x65, 0x82, 0x5d, 0x6a, 0xdc, 0x44, 0x65, 0x44, 0x02, 0x74, 0xaa, 0x8d,
  0xea, 0x1d, 0xc9, 0x09, 0x24, 0x1f, 0x4c, 0x0d, 0x8b, 0x34, 0xd7, 0x7f, 0x47, 0x15, 0x1d, 0x54, 0x02, 0x6d, 0xb5, 0x8b,
  0x95, 0x43, 0x4b, 0x63, 0xaf, 0x42, 0x10, 0x64, 0x56, 0x40, 0x73, 0x6d, 0x2d, 0xe1, 0xa2, 0x41, 0x53, 0x3f, 0xaf, 0x40,
  0xa1, 0x5b, 0x7a, 0x2b, 0x5f, 0x6b, 0x81, 0xff, 0xe6, 0x21, 0x8d, 0xd9, 0x99, 0x18, 0xcc, 0x8e, 0xe5, 0x08, 0xb2, 0x0e,
  0xe4, 0x8b, 0xe8, 0xea, 0x8f, 0xb0, 0x7b, 0xaa, 0x15, 0x2a, 0x57, 0xa9, 0x49, 0x95, 0x43, 0xf2, 0x00, 0xe7, 0x91, 0xb7,
  0x5c, 0x8f, 0x9d, 0x5f, 0xbc, 0x70, 0x43, 0xc3, 0x4b, 0x61, 0xfd, 0xe4, 0x58, 0xec, 0xa4, 0x03, 0x76, 0xd5, 0x37, 0xde,
  0x49, 0x39, 0x96, 0xfe, 0x74, 0x9b, 0x44, 0x18, 0x9d, 0x35, 0xd3, 0x36, 0x94, 0x75, 0x6f, 0x64, 0x63, 0xe6, 0x0c, 0x2c,
  0x14, 0xdf, 0x52, 0x63, 0x80, 0x0f, 0x6a, 0xc7, 0x8d, 0x54, 0xd0, 0xc5, 0x57, 0xab, 0x8c, 0x29, 0x52, 0x40, 0x1f, 0xc9,
  0x15, 0x59, 0xab, 0xfe, 0x50, 0x2d, 0xfa, 0x01, 0xf5, 0x79, 0x6e, 0x6b, 0x21, 0x17, 0xda, 0x11, 0x56, 0x22, 0x07, 0x27,
  0x86, 0xa1, 0xc0, 0x29, 0x3e, 0xa2, 0x5c, 0x8a, 0x86, 0x06, 0x8a, 0x5e, 0x64, 0xeb, 0x70, 0xd3, 0x79, 0xb1, 0xa2, 0x4b,
  0x91, 0x1d, 0x8c, 0x35, 0xc6, 0xfb, 0xcd, 0x30, 0x60, 0x45, 0x9c, 0x82, 0xf5, 0xbd, 0x1b, 0xd0, 0x91, 0x40, 0xba, 0x46,
  0xc3, 0x81, 0x93, 0x6c, 0x37, 0x2b, 0xe2, 0x0b, 0x58, 0xb5, 0xf9, 0xe4, 0x78, 0x9d, 0x1d, 0x0d, 0xc6, 0x49, 0xf2, 0x94,
  0x96, 0x80, 0x9c, 0xd0, 0xd4, 0xbf, 0x6d, 0x03, 0xf8, 0x17, 0xaf, 0x4d, 0x8b, 0xae, 0x56, 0x99, 0x71, 0x38, 0x9e, 0x8f,
  0xa7, 0xc9, 0x30, 0xf0, 0xba, 0xe9, 0x3c, 0xcd, 0x0d, 0xdf, 0xf1, 0xa3, 0x20, 0x76, 0x56, 0xa0, 0x6b, 0x26, 0x9b, 0xf0,
  0xfc, 0x1c, 0x68, 0x4a, 0x22, 0x5b, 0xe7, 0xae, 0x35, 0x18, 0x79, 0x52, 0x3c, 0x2e, 0xc5, 0x57, 0x2b, 0x6e, 0x2a, 0x01,
  0x10, 0xf1, 0xf3, 0x85, 0x1f, 0x26, 0x42, 0x09, 0x7c, 0xab, 0x6c, 0x24, 0x26, 0x47, 0xb9, 0x1b, 0x72, 0x3a, 0xd9, 0x08,
  0xbf, 0x6f, 0x8d, 0xad, 0x86, 0xa9, 0x84, 0x88, 0xc6, 0xcb, 0xb4, 0xb3, 0x12, 0x64, 0x55, 0x04, 0xcc, 0x20, 0x5c, 0x3c,
  0x75, 0x93, 0x68, 0x49, 0x55, 0x27, 0x5a, 0x45, 0x8c, 0xd1, 0x58, 0xf5, 0x55, 0x04, 0xfb, 0xe4, 0x5d, 0xc6, 0x0e, 0x66,
  0x21, 0x3e, 0x05, 0x64, 0x0c, 0x9b, 0x78, 0x27, 0x50, 0xf1, 0x60, 0x42, 0x46, 0x66, 0x1a, 0xe7, 0xc5, 0x66, 0x13, 0x6d,
  0xcc, 0xd6, 0x08, 0x08, 0xf4, 0xbe, 0x98, 0xa4, 0xbe, 0xc2, 0x43, 0x67, 0x3f, 0xbd, 0xfb, 0x45, 0x6c, 0xe2, 0xec, 0x60,
  0xf0, 0x33, 0x9b, 0x74, 0x8a, 0x1a, 0x60, 0xee, 0x40, 0x3c, 0x2e, 0x07, 0x9b, 0x1c, 0x4f, 0xa5, 0x11, 0x31, 0x4f, 0x95,
  0xfa, 0x63, 0x96, 0xb2, 0x66, 0x17, 0xe4, 0x50, 0x14, 0xc6, 0xe6, 0x57, 0xc9, 0xfa, 0xff, 0x62, 0xbb, 0x9c, 0xc1, 0xd1,
  0x7e, 0x4a, 0xd6, 0x3a, 0x2f, 0xbb, 0xd8, 0x44, 0xab, 0x10, 0x90, 0x05, 0x66, 0xbd, 0x0f, 0x89, 0x75, 0x33, 0xa2, 0x71,
  0x70, 0xe4, 0xc8, 0xc6, 0x6f, 0xe5, 0x57, 0xfb, 0x7e, 0x12, 0xc4, 0x1d, 0xb7, 0xd3, 0xb7, 0x53, 0x1b, 0x9e, 0x4c, 0x35,
  0xcd, 0x61, 0x2a, 0xdc, 0xb4, 0xa7, 0x4f, 0x49, 0x52, 0x50, 0xe4, 0xb3, 0xee, 0xac, 0xa3, 0xab, 0x60, 0x53, 0x77, 0x5e,
  0xbd, 0x78, 0x9e, 0xba, 0x6c, 0x85, 0x2c, 0x69, 0x8e, 0xc4, 0x11, 0x0e, 0xfa, 0xbd, 0xe3, 0xe1, 0x72, 0xa9, 0xef, 0x58,
  0x97, 0x07, 0xee, 0x00, 0x15, 0xa1, 0xd4, 0x7d, 0x21, 0x50, 0x2c, 0x6a, 0x1d, 0x00, 0x44, 0x69, 0x76, 0x0a, 0x1e, 0xbf,
  0x85, 0x8d, 0x1f, 0x42, 0x07, 0x40, 0xb8, 0x5d, 0x0b, 0xde, 0x7a, 0x15, 0x4c, 0x1d, 0x8e, 0xd0, 0xff, 0x4f, 0x06, 0x10,
  0x25, 0x12, 0x7c, 0x23, 0x13, 0x00, 0xc0, 0xc3, 0x14, 0x2e, 0x34, 0xb0, 0xfc, 0xb2, 0x89, 0xe6, 0x18, 0xb2, 0x0f, 0xf8,
  0xc1, 0xa2, 0x46, 0x9d, 0xc4, 0x53, 0x27, 0x5a, 0xd3, 0x96, 0xfb, 0x4f, 0x06, 0x19, 0xa9, 0xe5, 0x7e, 0x21, 0x70, 0x6c,
  0x7a, 0x2e, 0x00, 0xc7, 0x50, 0x75, 0x15, 0x64, 0x5e, 0x07, 0xcb, 0x68, 0x73, 0x53, 0x17, 0x66, 0xfc, 0x7a, 0xca, 0xa0,
  0xff, 0xf1, 0x30, 0x49, 0x29, 0x91, 0x95, 0x83, 0x6a, 0xc9, 0x7f, 0x8f, 0x32, 0xbe, 0x12, 0x3d, 0x4d, 0x8d, 0x30, 0x35,
  0x9f, 0xfe, 0x80, 0xe7, 0x30, 0xe0, 0xd3, 0x7a, 0xe4, 0x48, 0xf9, 0x16, 0x1e, 0x7e, 0x8c, 0x0c, 0x29, 0x3b, 0xd5, 0x2a,
  0x4f, 0xbf, 0x7f, 0xf5, 0x42, 0x5e, 0xe4, 0x1a, 0x38, 0x01, 0xb2, 0x8e, 0x58, 0xd5, 0x9c, 0x26, 0xc4, 0x4b, 0xe2, 0xe2,
  0xda, 0xaf, 0xc2, 0x24, 0x59, 0x04, 0x3f, 0xbc, 0x45, 0x01, 0xcb, 0x57, 0xf5, 0xe6, 0xf6, 0x1a, 0x82, 0xe6, 0xa7, 0xe4,
  0xf6, 0x00, 0xaf, 0x0b, 0x2a, 0x9d, 0x9a, 0xfa, 0xa9, 0x19, 0xa9, 0xa0, 0xfa, 0x45, 0x5b, 0x45, 0x7b, 0x68, 0xa7, 0xe1,
  0x8e, 0x74, 0xab, 0x13, 0xb2, 0xfd, 0x8c, 0xaa, 0x5a, 0xac, 0xa0, 0x5e, 0x85, 0x14, 0x4c, 0x60, 0x17, 0x4b, 0x38, 0x4c,
  0xa6, 0xad, 0x49, 0xc1, 0xa9, 0x4f, 0x89, 0xfb, 0x29, 0x94, 0x47, 0x53, 0x69, 0xaf, 0x58, 0x32, 0x8d, 0xa5, 0xba, 0x95,
  0x11, 0x0d, 0x0f, 0x93, 0x51, 0x59, 0x32, 0xe5, 0x90, 0xee, 0x80, 0xca, 0x36, 0x9d, 0x67, 0x17, 0x98, 0xd1, 0x1d, 0x98,
  0x82, 0x77, 0x19, 0x50, 0xf4, 0x39, 0x8d, 0x1a, 0xbd, 0x0b, 0xd4, 0x5e, 0xbc, 0xdd, 0x5c, 0xa2, 0xff, 0x8a, 0x38, 0x05,
  0xa2, 0x00, 0xe6, 0x9b, 0x88, 0x59, 0xa0, 0xd4, 0xf5, 0x1e, 0x5d, 0xae, 0x97, 0x67, 0xfb, 0x8e, 0x04, 0x7a, 0x48, 0x40,
  0xa3, 0x66, 0x55, 0x20, 0x96, 0xa3, 0x4e, 0xe3, 0x04, 0x1e, 0x00, 0x0a, 0xde, 0x85, 0xe7, 0xab, 0x40, 0xf8, 0x7b, 0x1c,
  0xba, 0xaa, 0xa3, 0xe9, 0xa4, 0x82, 0xb2, 0xb7, 0x88, 0x23, 0x67, 0x15, 0x04, 0x78, 0x70, 0x48, 0xc1, 0x38, 0x23, 0x1e,
  0x3b, 0x01, 0xcf, 0x7e, 0xac, 0xdd, 0x59, 0xcc, 0x30, 0x8d, 0xc9, 0xf5, 0xa4, 0x04, 0x63, 0x67, 0xe3, 0xc1, 0x6f, 0x7c,
  0x01, 0x0a, 0xff, 0x95, 0x87, 0x72, 0x07, 0x08, 0xdf, 0x30, 0xcd, 0x65, 0x94, 0x04, 0x8b, 0x9b, 0x3b, 0xcb, 0xcd, 0x87,
  0x68, 0x73, 0xe9, 0x7a, 0x31, 0xcb, 0x59, 0x67, 0xd4, 0xb9, 0x6f, 0xb1, 0x01, 0x84, 0xb9, 0x38, 0x6f, 0x80, 0x29, 0xc4,
  0xea, 0x23, 0x8b, 0xd5, 0x81, 0xa2, 0x91, 0x2c, 0xef, 0x89, 0xb2, 0x9e, 0xfe, 0xfd, 0xff, 0xfd, 0xff, 0x74, 0xa1, 0x4f,
  0x47, 0x00, 0x1e, 0x5b, 0x12, 0x26, 0x0b, 0x72, 0x4f, 0xdf, 0x2c, 0x02, 0xb4, 0x23, 0xa9, 0x33, 0x17, 0xdd, 0xf5, 0xf5,
  0x11, 0x0b, 0x98, 0x62, 0x11, 0x82, 0x78, 0xbb, 0x48, 0x8a, 0x6c, 0x1f, 0xba, 0xf1, 0xe4, 0xea, 0xcb, 0x0d, 0x27, 0x57,
  0xa9, 0xd1, 0xc4, 0xea, 0x66, 0x28, 0x53, 0x21, 0x0b, 0xe7, 0xc6, 0xf8, 0xfd, 0x26, 0xc0, 0xb3, 0x19, 0x88, 0x65, 0xc2,
  0x71, 0x47, 0x73, 0xa3, 0xf3, 0x6f, 0xdf, 0xbf, 0xa3, 0x01, 0xc6, 0x79, 0x67, 0x99, 0x89, 0xff, 0x6f, 0x53, 0x23, 0x0e,
  0xee, 0xba, 0x39, 0x10, 0x04, 0xdc, 0xbc, 0x54, 0x55, 0x62, 0xac, 0xda, 0xfb, 0x34, 0x95, 0x3a, 0x6c, 0x82, 0x2b, 0x54,
  0x16, 0xc5, 0x0e, 0x79, 0xb6, 0x08, 0xbc, 0x0d, 0x6e, 0xea, 0x95, 0xdc, 0xa5, 0x63, 0x28, 0x41, 0x10, 0xf2, 0x2e, 0xf9,
  0x5c, 0xdd, 0x1c, 0x3a, 0xcc, 0xeb, 0x82, 0x79, 0xd3, 0x4c, 0x6e, 0x5a, 0x62, 0xe3, 0xa6, 0xc2, 0xfd, 0x4f, 0x51, 0x3a,
  0xb3, 0x38, 0x84, 0x05, 0x90, 0x7d, 0x66, 0x88, 0xf8, 0x1d, 0x00, 0x5b, 0x30, 0x0c, 0x5e, 0xc6, 0x29, 0xfb, 0x1f, 0x1b,
  0x1b, 0x49, 0xbb, 0x75, 0xe3, 0x0f, 0x7f, 0x73, 0x60, 0x00, 0x21, 0x50, 0x83, 0x8c, 0xe6, 0x74, 0x65, 0xf8, 0x31, 0x7f,
  0x2d, 0x70, 0x5f, 0x16, 0x29, 0x40, 0xa2, 0x3f, 0xa7, 0x0a, 0xb3, 0xc5, 0x7d, 0x5b, 0x2b, 0x6e, 0xfc, 0x0d, 0x14, 0x7d,
  0x9a, 0xb0, 0xb3, 0x17, 0xab, 0x65, 0xe1, 0x92, 0xb1, 0x13, 0x19, 0xcb, 0x9f, 0x6b, 0x4c, 0xa1, 0x78, 0x41, 0x63, 0x39,
  0x43, 0xc2, 0x1f, 0x7e, 0x6b, 0x7c, 0xff, 0x2f, 0xbd, 0x7e, 0xab, 0x05, 0xeb, 0x0f, 0x74, 0xcb, 0x79, 0x7b, 0x81, 0x90,
  0x44, 0xac, 0x59, 0xe8, 0xf3, 0x98, 0x6f, 0xa2, 0xa5, 0xe3, 0x69, 0xcc, 0x03, 0x97, 0x70, 0xec, 0x7c, 0x0a, 0xd6, 0x74,
  0xd4, 0xf9, 0xcd, 0xd3, 0xd7, 0x84, 0x7e, 0xb3, 0x1c, 0x2e, 0xe5, 0xb0, 0xa6, 0x64, 0x25, 0xd3, 0x73, 0x53, 0x12, 0x93,
  0x40, 0xe4, 0x89, 0x13, 0x10, 0x9c, 0x1a, 0x9a, 0x87, 0x24, 0x5f, 0x41, 0xb8, 0x23, 0xa5, 0x50, 0xf1, 0x23, 0xd7, 0xf9,
  0x25, 0xd8, 0xc4, 0xf0, 0xeb, 0x95, 0xf0, 0x49, 0x22, 0x97, 0x12, 0xa8, 0x27, 0xa4, 0x30, 0x85, 0xd9, 0x2c, 0xa7, 0x91,
  0xee, 0xe9, 0xf1, 0x65, 0xf3, 0xbc, 0x37, 0x74, 0x0b, 0x29, 0xd5, 0x23, 0x3e, 0x23, 0x55, 0x67, 0x47, 0x1a, 0xb0, 0xc8,
  0x76, 0x13, 0x2e, 0xe9, 0x84, 0x0f, 0x12, 0xff, 0x3a, 0x40, 0x64, 0xb6, 0xd8, 0xfa, 0xcc, 0x13, 0x62, 0x74, 0x64, 0x04,
  0xc7, 0xcc, 0x68, 0x56, 0x3a, 0xff, 0xf5, 0x95, 0xa4, 0x08, 0x98, 0xbb, 0xc5, 0x33, 0x5a, 0x71, 0xd3, 0x79, 0x05, 0x85,
  0x37, 0x62, 0x83, 0xc8, 0x0d, 0xbd, 0xdd, 0x20, 0x9b, 0x4d, 0xb0, 0x17, 0x02, 0xf5, 0x18, 0x56, 0x42, 0x80, 0x97, 0xfe,
  0x8d, 0xf0, 0xbb, 0x36, 0x6a, 0xda, 0xb6, 0xf1, 0xca, 0x5b, 0x03, 0x2b, 0x49, 0x40, 0xe6, 0x8c, 0xa0, 0xfc, 0x82, 0xda,
  0x15, 0xad, 0x39, 0x4b, 0x68, 0x6b, 0x8a, 0x27, 0x6d, 0x37, 0xe7, 0x11, 0xe0, 0xcd, 0xaa, 0xe9, 0xfc, 0x3c, 0x9f, 0xd3,
  0x89, 0xf6, 0x18, 0xa9, 0x83, 0x04, 0x90, 0x58, 0x59, 0xc4, 0x0c, 0x1a, 0x8c, 0x1f, 0xc6, 0xb8, 0x03, 0x62, 0xd9, 0xab,
  0x43, 0x59, 0x49, 0xd2, 0xd1, 0x34, 0xcd, 0x5d, 0x4c, 0xae, 0x06, 0x85, 0x6d, 0x24, 0x3c, 0xc0, 0x32, 0xd1, 0x39, 0x32,
  0xeb, 0x52, 0x1d, 0x39, 0x74, 0xba, 0xec, 0x88, 0xee, 0xe0, 0x99, 0x46, 0xd7, 0x47, 0x8e, 0xb8, 0x8d, 0x47, 0x73, 0x9f,
  0x00, 0x75, 0x9b, 0xde, 0x14, 0xad, 0x32, 0x32, 0x51, 0x92, 0x4a, 0xc8, 0xa5, 0xf6, 0x7d, 0xa6, 0x0c, 0xa9, 0xec, 0x4d,
  0xd1, 0x64, 0xed, 0x28, 0x63, 0xad, 0x5f, 0x48, 0xac, 0x14, 0x33, 0xa0, 0xde, 0x0e, 0x22, 0x37, 0x86, 0xf1, 0xc2, 0x80,
  0x7d, 0xd1, 0xf6, 0x57, 0xa3, 0xa7, 0xe2, 0xbc, 0xf9, 0x33, 0xcb, 0x76, 0xc0, 0xbe, 0x37, 0x5a, 0x91, 0x1b, 0xff, 0xe9,
  0x95, 0x8c, 0x94, 0xb1, 0x61, 0x30, 0x6d, 0xc6, 0x52, 0x27, 0x45, 0x16, 0xb0, 0xb2, 0xdd, 0xe7, 0x24, 0x69, 0xaa, 0x89,
  0x09, 0x39, 0x49, 0x4e, 0xeb, 0xb0, 0xfd, 0x4d, 0x47, 0xd4, 0x8e, 0x24, 0x5e, 0xcc, 0x31, 0x3e, 0x76, 0x9a, 0xbc, 0xf6,
  0x56, 0x5b, 0x6f, 0x21, 0x34, 0x47, 0x29, 0xea, 0xac, 0xf9, 0x51, 0xad, 0x02, 0x73, 0x30, 0x31, 0x40, 0xb3, 0x46, 0x76,
  0xcd, 0x8d, 0xaf, 0xbc, 0xe4, 0x14, 0x71, 0x50, 0xa3, 0xb5, 0xa5, 0x76, 0xee, 0x3c, 0x34, 0x4a, 0xb6, 0x71, 0x74, 0x2a,
  0x7f, 0xed, 0x19, 0x16, 0x97, 0x2e, 0x1c, 0x17, 0x7d, 0xfe, 0xba, 0x81, 0xa5, 0x16, 0x3d, 0x8b, 0x34, 0x6f, 0x1f, 0x9d,
  0xaa, 0x92, 0x1d, 0x97, 0xfc, 0x90, 0x19, 0x11, 0xab, 0xec, 0x56, 0x8b, 0xa1, 0xf8, 0x94, 0x2f, 0xf2, 0xf6, 0xc6, 0x5f,
  0x05, 0x37, 0xf9, 0x02, 0x31, 0x7c, 0x7b, 0x17, 0x7d, 0xba, 0x89, 0xec, 0x9f, 0xde, 0xe2, 0x70, 0x2e, 0xbc, 0x30, 0xf7,
  0xf5, 0xc5, 0x76, 0x13, 0xad, 0x83, 0xe3, 0x57, 0x11, 0xa8, 0x32, 0xab, 0x7c, 0x5d, 0x3a, 0xe6, 0xee, 0x1d, 0xff, 0x14,
  0x5c, 0x7d, 0xfc, 0x57, 0x32, 0xcf, 0x14, 0x14, 0x78, 0x15, 0xc5, 0x1f, 0x9f, 0xc2, 0x84, 0x49, 0x61, 0xcb, 0x94, 0xf9,
  0xf5, 0xdd, 0xb3, 0xf4, 0x9d, 0x5a, 0x05, 0x5d, 0x6c, 0x43, 0x26, 0xf9, 0xbd, 0xc8, 0xe4, 0xa1, 0x85, 0xd0, 0x83, 0x50,
  0x05, 0xea, 0x82, 0xbf, 0x45, 0x09, 0x9c, 0x99, 0x03, 0xa7, 0x29, 0xd0, 0x54, 0x21, 0x4d, 0x1b, 0x93, 0x7a, 0xa5, 0x50,
  0xc7, 0xc2, 0xd8, 0xf4, 0x0f, 0x60, 0x35, 0xd6, 0xbf, 0x80, 0x2a, 0x2f, 0xa2, 0xab, 0x66, 0x91, 0x18, 0x54, 0x88, 0x0d,
  0x3f, 0x53, 0xed, 0x1c, 0x3e, 0x70, 0xa3, 0xc5, 0x18, 0x21, 0xaa, 0xd9, 0x70, 0x82, 0x3f, 0x15, 0xe1, 0x69, 0x16, 0x42,
  0x4f, 0x7d, 0x9f, 0x92, 0x65, 0x7a, 0x0b, 0x39, 0x11, 0x6f, 0xbd, 0x5e, 0x84, 0x24, 0x0a, 0x00, 0xdd, 0x00, 0x4e, 0x9b,
  0x77, 0x8f, 0x14, 0xce, 0xb2, 0x4c, 0x59, 0x12, 0xee, 0x47, 0xa5, 0x21, 0xde, 0xcd, 0xe9, 0x68, 0x4a, 0xc2, 0xce, 0x2a,
  0xba, 0x4a, 0xb5, 0xa7, 0x22, 0xc5, 0x4c, 0xca, 0xb4, 0xeb, 0x85, 0x37, 0x63, 0x0f, 0x6a, 0xae, 0x43, 0xd4, 0xc4, 0xe8,
  0x8b, 0xec, 0x8c, 0xb4, 0xd2, 0x63, 0xd4, 0x9e, 0xb1, 0x52, 0xa6, 0xdb, 0xac, 0xc2, 0x96, 0x57, 0x68, 0x11, 0x65, 0x98,
  0x19, 0x23, 0xd4, 0x82, 0x6b, 0xc0, 0x23, 0xd2, 0xe9, 0x69, 0xd0, 0x53, 0xd0, 0xec, 0xf1, 0x89, 0x75, 0x72, 0x2c, 0x20,
  0xba, 0x21, 0x05, 0x76, 0x03, 0xb2, 0x37, 0xa8, 0xdd, 0x20, 0x3c, 0xe8, 0xb4, 0x9f, 0x90, 0x81, 0x9c, 0xbc, 0x42, 0x01,
  0xdf, 0xe3, 0x58, 0xd9, 0x6b, 0xa5, 0xf8, 0x31, 0xba, 0x92, 0xfa, 0xa7, 0xf3, 0x08, 0xc4, 0x09, 0xa4, 0x6d, 0xbc, 0x0d,
  0xd8, 0x52, 0x9a, 0xb7, 0x57, 0x10, 0x48, 0xb6, 0x6b, 0x12, 0xba, 0x50, 0xc1, 0xb9, 0xd2, 0x09, 0x3d, 0xcb, 0x3a, 0xb3,
  0x8b, 0x28, 0x12, 0xe6, 0x0a, 0x99, 0xe1, 0x08, 0x15, 0xec, 0x04, 0xda, 0xa7, 0xb0, 0x23, 0x96, 0xbf, 0x84, 0x7a, 0xef,
  0x2d, 0x43, 0xa9, 0x67, 0x1f, 0x2b, 0xfe, 0x5b, 0xc2, 0xd6, 0xd8, 0x3b, 0xcb, 0xae, 0x02, 0xcd, 0x0b, 0x5b, 0xe2, 0x82,
  0x37, 0xae, 0xfe, 0x52, 0xf2, 0x25, 0xce, 0x3a, 0xf0, 0x69, 0xb5, 0xd1, 0x01, 0xc4, 0x13, 0x93, 0x4b, 0x3b, 0x62, 0x89,
  0x45, 0x46, 0xb1, 0x4d, 0x0d, 0x30, 0x72, 0xcd, 0x86, 0x1f, 0x24, 0xc0, 0x4b, 0x85, 0x5e, 0xaa, 0xb5, 0xf6, 0x5c, 0xbe,
  0x67, 0x33, 0x1f, 0xc3, 0xfa, 0x27, 0x0f, 0xc3, 0xdb, 0xd2, 0x28, 0x4f, 0xad, 0x3c, 0x7e, 0x3a, 0x3a, 0xcd, 0x85, 0x65,
  0xe2, 0x56, 0xc4, 0x20, 0x92, 0x82, 0x5a, 0xe2, 0xeb, 0x91, 0xe1, 0x6d, 0xb2, 0xb4, 0x22, 0x18, 0x68, 0x41, 0x2b, 0x8a,
  0x5d, 0x5b, 0x2b, 0xd2, 0xca, 0x15, 0xd7, 0x14, 0xdc, 0x74, 0x8f, 0xc6, 0xa7, 0x89, 0x39, 0x4f, 0x17, 0x57, 0xde, 0x4d,
  0x8c, 0x21, 0xc0, 0x4a, 0xca, 0xa1, 0x37, 0x0e, 0xbe, 0xca, 0x80, 0xbc, 0xd8, 0xef, 0x73, 0xa8, 0x6e, 0xce, 0x98, 0xea,
  0x39, 0x7f, 0xf8, 0xed, 0xef, 0x7f, 0xfb, 0xaf, 0xac, 0x1b, 0xd9, 0x47, 0x77, 0xea, 0x36, 0x9d, 0x97, 0x2b, 0x47, 0xf3,
  0x98, 0x38, 0x7f, 0xff, 0xbf, 0xff, 0x9b, 0xd0, 0x0d, 0x53, 0xe3, 0xcc, 0x69, 0x5d, 0xec, 0x7f, 0x8d, 0x83, 0x08, 0xb4,
  0x27, 0xac, 0x87, 0xfa, 0x5a, 0x57, 0xce, 0xeb, 0x97, 0xe8, 0x44, 0x3a, 0x55, 0x3b, 0xa0, 0x89, 0xf1, 0xe4, 0xed, 0xa6,
  0xf3, 0x0b, 0x2e, 0x1b, 0x16, 0xa6, 0xe1, 0xc9, 0xa0, 0x89, 0x53, 0xfa, 0xdc, 0x01, 0xf9, 0x7d, 0x95, 0x36, 0x5f, 0x77,
  0x2e, 0xa2, 0x05, 0x35, 0xfc, 0x8c, 0x9a, 0x42, 0x3b, 0x00, 0xec, 0x22, 0xd0, 0xcd, 0x40, 0x22, 0xec, 0x38, 0x9c, 0x67,
  0x37, 0xd6, 0x08, 0x88, 0xae, 0xd6, 0xd1, 0x01, 0x46, 0x31, 0xae, 0x67, 0x3f, 0xff, 0xf4, 0xd3, 0x8b, 0x67, 0xef, 0x9c,
  0xdf, 0x5e, 0xbe, 0xfb, 0xd1, 0x79, 0xea, 0xfc, 0xf2, 0xe3, 0xcf, 0x3f, 0xbd, 0xe0, 0x16, 0xd9, 0x20, 0x00, 0x5d, 0x77,
  0x9b, 0xba, 0xa9, 0x0c, 0xb4, 0xbf, 0x55, 0xac, 0xcd, 0x93, 0x35, 0x07, 0x52, 0x12, 0xf0, 0xa5, 0x76, 0xc9, 0x01, 0xb1,
  0x3d, 0x45, 0x95, 0x98, 0x56, 0x05, 0x7e, 0xf3, 0x2b, 0x97, 0xee, 0x9d, 0x70, 0x60, 0x7b, 0x3a, 0x49, 0x2a, 0x5e, 0xbd,
  0xb7, 0xe9, 0xba, 0xac, 0xb5, 0x5d, 0x6c, 0x2c, 0xcf, 0x5a, 0xc2, 0xbd, 0x98, 0x81, 0x9c, 0xca, 0x35, 0x82, 0x45, 0x30,
  0xf0, 0x06, 0x15, 0x28, 0xe4, 0xa5, 0x48, 0xcb, 0x91, 0x52, 0xbe, 0x8e, 0x7c, 0xf4, 0x9d, 0xc9, 0x16, 0x9f, 0x13, 0x2c,
  0x23, 0x54, 0xd0, 0x81, 0x2a, 0x2a, 0x1f, 0xbe, 0xd4, 0x24, 0x19, 0x3e, 0xb3, 0x68, 0x23, 0x72, 0xa4, 0xc9, 0xa5, 0x7e,
  0x39, 0x87, 0x5e, 0x28, 0x6b, 0x76, 0x04, 0x3a, 0x1a, 0xca, 0xfb, 0xd2, 0x91, 0x0f, 0x72, 0x85, 0xb7, 0x40, 0x95, 0xfd,
  0xc6, 0xc1, 0xf3, 0x84, 0xa2, 0x2b, 0xec, 0x99, 0x06, 0xef, 0x9d, 0x63, 0x6c, 0x96, 0x34, 0xc5, 0xa2, 0xbd, 0x32, 0x5c,
  0x01, 0x51, 0xf4, 0xd0, 0xa0, 0x0b, 0xaf, 0x31, 0xe8, 0x00, 0xcb, 0x7a, 0xce, 0x39, 0x9e, 0x45, 0x04, 0x01, 0x66, 0xba,
  0x8d, 0x6f, 0xd8, 0x68, 0xff, 0xb5, 0x0b, 0x23, 0x36, 0x2c, 0x0d, 0x76, 0x09, 0x50, 0x28, 0xd9, 0xef, 0x9e, 0xda, 0xed,
  0x3f, 0x06, 0x8b, 0x35, 0x68, 0x04, 0x17, 0xc1, 0x4a, 0xea, 0x1b, 0x75, 0x0d, 0xd9, 0x30, 0xb4, 0x2c, 0x5c, 0x6d, 0x01,
  0x06, 0x2a, 0x24, 0x83, 0x4d, 0x5e, 0xc4, 0x86, 0x04, 0x34, 0x63, 0xb6, 0x5c, 0x18, 0x56, 0xb0, 0x27, 0xe1, 0x29, 0xaf,
  0xf6, 0x93, 0xe3, 0xf0, 0x54, 0xc4, 0x39, 0x38, 0x2f, 0x13, 0x61, 0xf4, 0x12, 0x38, 0x0c, 0x94, 0x6b, 0xbb, 0xfa, 0xb4,
  0xc2, 0x60, 0x0a, 0x5e, 0xea, 0x70, 0xc5, 0x82, 0x1b, 0x8e, 0xbe, 0xe9, 0x68, 0x56, 0x7a, 0x61, 0x68, 0xe7, 0x11, 0x48,
  0x9b, 0x1b, 0x52, 0x10, 0xd3, 0x1e, 0xbd, 0x56, 0xbe, 0xb1, 0x2d, 0xad, 0x08, 0x17, 0x52, 0x83, 0x92, 0xdb, 0x3d, 0x6e,
  0x7e, 0x99, 0xd7, 0xfa, 0xc0, 0x90, 0x8b, 0x54, 0x38, 0x65, 0x43, 0x48, 0x61, 0xec, 0xc5, 0xa1, 0xcb, 0xcc, 0x5e, 0x22,
  0x9b, 0xe7, 0x08, 0x15, 0x78, 0x3c, 0x1d, 0x89, 0x09, 0x9e, 0x24, 0x21, 0x4f, 0x30, 0x33, 0x09, 0x3a, 0xbb, 0xc9, 0x92,
  0xca, 0xdf, 0x84, 0xe6, 0x9c, 0xd2, 0x86, 0xb8, 0xf0, 0xa8, 0x41, 0x71, 0xc3, 0xb3, 0x4f, 0xd6, 0x46, 0x3d, 0xb2, 0x1e,
  0x10, 0x89, 0xf9, 0x82, 0x56, 0xd9, 0x3b, 0x65, 0x6b, 0x37, 0xe3, 0xd1, 0xb2, 0xb1, 0xb2, 0xbd, 0xb1, 0x2b, 0x07, 0x79,
  0x83, 0x7e, 0x4b, 0x85, 0x9d, 0x30, 0x90, 0x71, 0x5c, 0x0a, 0x57, 0x6c, 0x72, 0x56, 0x6a, 0xd0, 0x63, 0x35, 0x05, 0x97,
  0x19, 0xd0, 0x16, 0xda, 0xde, 0x90, 0x38, 0x8e, 0x38, 0xae, 0xf6, 0x04, 0x0a, 0x6b, 0x88, 0x8c, 0xe2, 0x34, 0x33, 0xe0,
  0x75, 0x2a, 0xc7, 0x23, 0xa2, 0x2f, 0x38, 0xc9, 0x9a, 0x92, 0xc6, 0x66, 0x40, 0x11, 0x43, 0x9f, 0xd2, 0x1f, 0x52, 0x1b,
  0xeb, 0xed, 0x14, 0x70, 0x0e, 0x48, 0xd6, 0x7a, 0x41, 0xe2, 0x27, 0x05, 0xc3, 0xc4, 0x63, 0x79, 0x68, 0x09, 0xf4, 0x06,
  0x2c, 0x8d, 0xf4, 0x1e, 0x86, 0x00, 0x14, 0x09, 0x05, 0x57, 0x24, 0xbb, 0x92, 0x3f, 0x18, 0x19, 0xc1, 0xf2, 0xbe, 0xa1,
  0xed, 0x22, 0x3d, 0xf6, 0x9d, 0x4d, 0x1d, 0x86, 0x5a, 0x50, 0x28, 0x17, 0x4c, 0x9b, 0x35, 0xf0, 0xcf, 0x91, 0x5a, 0x2d,
  0xd8, 0xb5, 0x17, 0x01, 0xae, 0xbe, 0x9f, 0x42, 0xa3, 0x2e, 0xdc, 0xd1, 0x1e, 0x2a, 0x50, 0x2b, 0xcc, 0xf9, 0x48, 0xcc,
  0x9b, 0x88, 0xfd, 0x34, 0x63, 0x12, 0x6e, 0xe2, 0x21, 0x5d, 0xa3, 0x23, 0x90, 0x40, 0xd0, 0xe6, 0x87, 0xb6, 0xb0, 0xf3,
  0x30, 0x81, 0x36, 0x8e, 0x9d, 0x8b, 0x9b, 0x29, 0x46, 0xa8, 0x56, 0x83, 0xeb, 0x35, 0xf4, 0x45, 0x60, 0x58, 0xd4, 0xb4,
  0x31, 0xc0, 0xd8, 0x97, 0xdb, 0x15, 0x8c, 0xdb, 0x0e, 0x47, 0x20, 0x18, 0xba, 0x4d, 0x90, 0x5b, 0xa5, 0x94, 0xcd, 0xdc,
  0xae, 0x5c, 0x7c, 0x83, 0x5d, 0x91, 0x44, 0x2c, 0x56, 0x4e, 0x63, 0x55, 0xa2, 0x79, 0x4e, 0x8e, 0x2a, 0x65, 0x90, 0xfc,
  0x24, 0x9e, 0xc2, 0xe4, 0xa3, 0xf3, 0x2d, 0x73, 0x98, 0x06, 0x32, 0x69, 0x6d, 0xb8, 0xfa, 0x34, 0x80, 0x2f, 0xaf, 0x31,
  0x77, 0x27, 0x9f, 0xbb, 0x12, 0x6b, 0x40, 0xbd, 0x89, 0x06, 0xd2, 0xc1, 0x31, 0xa6, 0x5e, 0xd0, 0x38, 0xc4, 0xcd, 0x09,
  0x12, 0xaa, 0x78, 0x68, 0x3c, 0x04, 0x54, 0x88, 0x71, 0x19, 0x36, 0xc0, 0x83, 0x48, 0x25, 0x96, 0x32, 0x13, 0x22, 0x18,
  0x06, 0x9f, 0x01, 0x01, 0x98, 0x87, 0xe7, 0x5b, 0xa0, 0xcb, 0xc0, 0x48, 0xe5, 0x0a, 0xa5, 0xa5, 0xd6, 0x6b, 0x20, 0xcc,
  0x2c, 0x50, 0xe0, 0x60, 0x08, 0x3b, 0xd3, 0x8d, 0x31, 0xe5, 0x9d, 0x3e, 0xbd, 0x21, 0xe8, 0x28, 0x7c, 0xd4, 0x08, 0xab,
  0x80, 0xc2, 0xf1, 0x76, 0x91, 0xdd, 0x31, 0x4f, 0xbc, 0xaf, 0x3c, 0xd4, 0x7f, 0x3c, 0x5d, 0x44, 0xd3, 0x63, 0x8c, 0x77,
  0x3e, 0xf6, 0xa3, 0x59, 0x7c, 0xfc, 0xdb, 0xd3, 0x77, 0xcf, 0x7e, 0xfc, 0xf8, 0xf6, 0xd7, 0x5f, 0x7e, 0xf9, 0xf9, 0xcd,
  0xbb, 0xe6, 0xd2, 0xbf, 0xcb, 0xa1, 0xff, 0xd7, 0x34, 0x2f, 0x03, 0xdd, 0x09, 0x86, 0xdb, 0x35, 0xde, 0x9b, 0xe0, 0x2d,
  0xd5, 0x96, 0x0d, 0xae, 0x3d, 0x9c, 0x65, 0xcc, 0xf9, 0x01, 0xd6, 0x87, 0x12, 0x1c, 0xcd, 0x37, 0x12, 0x5c, 0xc3, 0x62,
  0x14, 0x58, 0xd6, 0x0b, 0x49, 0x11, 0x65, 0xaa, 0x02, 0x26, 0x46, 0x49, 0xa7, 0x14, 0x3d, 0xc2, 0xe1, 0x07, 0x20, 0xc7,
  0xd8, 0x28, 0x52, 0xda, 0xe3, 0x0f, 0x9c, 0x70, 0x2a, 0x56, 0xda, 0x43, 0x7e, 0x99, 0x75, 0xdf, 0xca, 0x61, 0x9a, 0x9d,
  0xd1, 0x32, 0xd9, 0x53, 0x8f, 0x4e, 0xe9, 0x26, 0x12, 0xe1, 0x3e, 0xcf, 0x1e, 0x83, 0x50, 0xfc, 0x6d, 0xcf, 0x20, 0x9f,
  0xb2, 0xbf, 0x87, 0x56, 0x40, 0xe9, 0x04, 0x62, 0x3b, 0x28, 0xa6, 0x0e, 0x62, 0x9b, 0x42, 0x5b, 0xb2, 0xf5, 0xa7, 0x5e,
  0x22, 0xd9, 0x31, 0x51, 0xb5, 0x2c, 0x43, 0xcd, 0x7a, 0x3a, 0x8c, 0x9e, 0x5f, 0x83, 0x98, 0x1e, 0x6c, 0xde, 0xe0, 0x37,
  0x4d, 0x15, 0x2c, 0xf3, 0x79, 0x18, 0xd5, 0x85, 0x03, 0x5f, 0xf8, 0x3d, 0x9e, 0xae, 0xd7, 0x0b, 0xda, 0x14, 0x71, 0x3a,
  0x24, 0x69, 0xb6, 0xd2, 0x03, 0x0c, 0xa4, 0x07, 0x24, 0xf5, 0x03, 0x28, 0x29, 0xbe, 0x02, 0xdc, 0x43, 0x24, 0x93, 0x50,
  0x93, 0x22, 0x51, 0x97, 0x2c, 0x3c, 0xb1, 0xb0, 0xf0, 0xa0, 0x09, 0x8b, 0xc3, 0x7c, 0x52, 0xa1, 0x86, 0x8c, 0x59, 0xb2,
  0x37, 0x2c, 0xb1, 0x02, 0x9c, 0x73, 0x5e, 0xbc, 0xfd, 0xa5, 0xd3, 0x16, 0xa4, 0x58, 0x50, 0x2a, 0x04, 0xdd, 0x3c, 0x44,
  0x4c, 0x20, 0x32, 0xbd, 0x5d, 0xfb, 0x4c, 0x7c, 0xef, 0xe2, 0x4d, 0xb0, 0x01, 0x21, 0xef, 0x51, 0xc8, 0x79, 0x12, 0x8a,
  0x61, 0xa7, 0x59, 0xc5, 0x96, 0xde, 0x86, 0x0f, 0x36, 0xca, 0x82, 0xcf, 0x37, 0xa0, 0xd5, 0x54, 0xef, 0xe4, 0x44, 0xb0,
  0x47, 0xf8, 0x1b, 0x49, 0xd8, 0x0c, 0x7f, 0x5e, 0x1c, 0xce, 0xfe, 0xc0, 0x2f, 0x25, 0x16, 0x5c, 0x74, 0x4e, 0x9f, 0x73,
  0x9a, 0x3a, 0x74, 0xea, 0x6c, 0x81, 0x2a, 0x88, 0xfd, 0x47, 0x21, 0x16, 0xe6, 0x2e, 0xec, 0x64, 0xa9, 0xdc, 0x33, 0x36,
  0xae, 0xe4, 0xb7, 0x06, 0xab, 0x87, 0xab, 0x1b, 0xad, 0x01, 0x8a, 0x41, 0xf6, 0x23, 0x22, 0xcb, 0x57, 0x1e, 0xac, 0x3b,
  0xc3, 0xc1, 0x27, 0xf7, 0xe0, 0x26, 0x39, 0x5e, 0xa0, 0x8c, 0xc4, 0x87, 0x57, 0x60, 0x71, 0x99, 0xc1, 0xfb, 0x01, 0xf2,
  0x77, 0xc4, 0x06, 0x4d, 0xff, 0x23, 0x2a, 0x9d, 0x73, 0x01, 0xe6, 0x93, 0xe8, 0x65, 0x27, 0xfe, 0x03, 0x25, 0xb3, 0x3b,
  0x2a, 0x8d, 0xe3, 0x2c, 0x87, 0xdf, 0x53, 0xa4, 0x53, 0x79, 0xf8, 0xfd, 0x40, 0x47, 0xaa, 0xc9, 0x97, 0xc1, 0x94, 0x8c,
  0x41, 0x65, 0xdf, 0x9a, 0x87, 0xed, 0x3b, 0xea, 0x29, 0xb3, 0xeb, 0xde, 0xa2, 0x01, 0x74, 0x01, 0xfc, 0x09, 0xbb, 0xe3,
  0x8e, 0x10, 0x30, 0xe6, 0x56, 0x33, 0x15, 0x1b, 0xf6, 0xdf, 0xc9, 0xe2, 0xb4, 0x0f, 0xd8, 0x2a, 0x26, 0xa2, 0x6e, 0x62,
  0xb1, 0x9b, 0xa4, 0x4d, 0x51, 0xdf, 0x9e, 0xda, 0x84, 0xb4, 0x2d, 0xfa, 0x54, 0x6b, 0x48, 0x86, 0x01, 0xc9, 0x1a, 0x0b,
  0x0c, 0x2b, 0x96, 0x56, 0xd8, 0x3b, 0xef, 0x32, 0x63, 0xca, 0x87, 0xee, 0x31, 0x0b, 0x9c, 0xbe, 0xf1, 0x0e, 0xa3, 0xe5,
  0x32, 0x07, 0xf9, 0xf5, 0x88, 0xf4, 0xec, 0x02, 0x80, 0x94, 0x47, 0xa4, 0x1f, 0xa3, 0xed, 0x06, 0x1d, 0x62, 0xa0, 0xe2,
  0x79, 0x8b, 0x1c, 0x12, 0x59, 0xec, 0xf4, 0xd4, 0x18, 0xd7, 0xa2, 0x26, 0x8f, 0x64, 0x13, 0xb3, 0x0b, 0x8a, 0x02, 0xcf,
  0x9b, 0xe8, 0x73, 0x35, 0x0e, 0x03, 0x17, 0x53, 0x61, 0x87, 0x6c, 0xf6, 0x93, 0xa3, 0x86, 0x6b, 0x63, 0x87, 0x59, 0x3f,
  0x88, 0x2c, 0xed, 0xa2, 0x6d, 0xb4, 0xe8, 0x63, 0xeb, 0x08, 0xb9, 0x83, 0xc5, 0x5d, 0xf2, 0xc5, 0xb0, 0x45, 0xdb, 0xc8,
  0x26, 0x0f, 0xdb, 0x67, 0xe8, 0x0d, 0xf7, 0x51, 0xf5, 0x26, 0x29, 0xe3, 0xeb, 0xb7, 0x28, 0xf5, 0x93, 0xdf, 0xa1, 0x33,
  0xd5, 0x8f, 0xa2, 0x62, 0xd9, 0x4d, 0x9a, 0x69, 0xe3, 0x55, 0xb8, 0x0c, 0x13, 0xaa, 0xcc, 0xfc, 0x91, 0xc6, 0x57, 0x89,
  0x55, 0xfd, 0x71, 0x7a, 0x96, 0x82, 0xdd, 0xf3, 0x21, 0xea, 0x54, 0x0b, 0xd8, 0xb7, 0xc0, 0x0d, 0x37, 0xb8, 0x74, 0xe5,
  0x74, 0xf2, 0xce, 0x3b, 0x51, 0x9f, 0xd9, 0xa1, 0x1b, 0x31, 0x0f, 0x8d, 0x7f, 0xc4, 0x3e, 0x34, 0x10, 0x40, 0x4f, 0x51,
  0x7a, 0x74, 0xd0, 0x4e, 0xa1, 0x41, 0x22, 0xf2, 0xc7, 0xbc, 0x51, 0x62, 0xd5, 0x85, 0x0d, 0x02, 0x5c, 0x50, 0xcc, 0x7f,
  0xb5, 0x5d, 0x4e, 0x61, 0x6c, 0x98, 0x23, 0x97, 0x72, 0x4b, 0x2d, 0x3d, 0x4c, 0x84, 0x47, 0x89, 0x99, 0x82, 0x35, 0xa5,
  0x35, 0x51, 0x08, 0xed, 0xa0, 0x92, 0x02, 0xcd, 0x95, 0xce, 0xfb, 0x10, 0x2f, 0x5c, 0x3a, 0x94, 0xd7, 0xe1, 0x6a, 0x9b,
  0x60, 0x00, 0xa9, 0xf8, 0x51, 0x3a, 0x6e, 0x59, 0xb8, 0x6c, 0xe4, 0xbd, 0x93, 0xfc, 0xc8, 0x7b, 0xff, 0x88, 0x91, 0xbf,
  0x65, 0xbb, 0x30, 0xa2, 0x37, 0xfd, 0x28, 0x1d, 0xb9, 0x2c, 0x7c, 0xd7, 0x91, 0xdf, 0x09, 0xe6, 0x5f, 0xce, 0xfd, 0xb7,
  0x49, 0xf4, 0x94, 0xa2, 0x3a, 0xf3, 0xd4, 0x45, 0xe8, 0x31, 0x45, 0x21, 0xa0, 0xdf, 0x40, 0x20, 0x50, 0x9d, 0xe7, 0x49,
  0x8e, 0xce, 0x83, 0xd3, 0x21, 0x68, 0x01, 0xa8, 0xa9, 0x10, 0x96, 0x0a, 0x0a, 0xef, 0xd0, 0xee, 0x88, 0xe6, 0xce, 0x4d,
  0xb4, 0x30, 0xe5, 0x72, 0xa4, 0x5d, 0x69, 0x33, 0xd2, 0xe6, 0x89, 0xd6, 0xcc, 0x58, 0x68, 0xc8, 0x7e, 0x00, 0xba, 0x04,
  0xac, 0x8a, 0x88, 0x10, 0x92, 0x06, 0x3f, 0x3c, 0x3a, 0x05, 0x5b, 0x66, 0x4c, 0x2f, 0x59, 0x20, 0xd7, 0xbc, 0xd5, 0x22,
  0xf4, 0x97, 0x8e, 0xf2, 0xc6, 0xc1, 0xda, 0xdb, 0x7c, 0xa1, 0x34, 0x9e, 0x83, 0xc4, 0xc1, 0xb2, 0x82, 0x1d, 0x84, 0xff,
  0x70, 0x3a, 0x65, 0xc8, 0xa4, 0x07, 0xed, 0x9c, 0x74, 0xa4, 0x47, 0x5a, 0xe8, 0xb6, 0x8e, 0x4e, 0x05, 0x8c, 0x5d, 0xab,
  0xf8, 0x25, 0x7c, 0xfd, 0x6b, 0x38, 0xf5, 0x9d, 0xa6, 0xc5, 0x24, 0x0a, 0x3d, 0xfc, 0x0a, 0x47, 0x97, 0xf4, 0x4a, 0xf3,
  0xeb, 0x20, 0x2e, 0x15, 0x51, 0x8b, 0x5c, 0x4b, 0x77, 0xa5, 0x18, 0x9d, 0x6f, 0x45, 0x32, 0x0e, 0x0e, 0x2b, 0xc8, 0x99,
  0x14, 0x74, 0xe3, 0x3a, 0x3c, 0x1a, 0x03, 0xc0, 0xd3, 0xfd, 0x82, 0xba, 0x50, 0xf4, 0x60, 0xd6, 0xec, 0x50, 0xe2, 0xeb,
  0xcf, 0x77, 0xf6, 0x86, 0x02, 0x9a, 0x29, 0x1c, 0x2c, 0xca, 0xd9, 0x46, 0xc4, 0xf6, 0x26, 0x2f, 0x59, 0x2e, 0x8e, 0x93,
  0x03, 0xcf, 0x34, 0x1d, 0x50, 0x05, 0xe0, 0xab, 0xd0, 0x7b, 0x76, 0x02, 0x71, 0xcc, 0xb4, 0x11, 0x4f, 0xc8, 0x51, 0xf2,
  0xfc, 0x01, 0xf5, 0x8b, 0x08, 0xbd, 0x43, 0xde, 0x0c, 0xbd, 0x1f, 0xb0, 0xf5, 0xce, 0x95, 0x05, 0x9d, 0xd4, 0x11, 0x65,
  0x79, 0xd4, 0xc6, 0xe5, 0xf9, 0x68, 0x7f, 0x53, 0xa4, 0x02, 0x4d, 0x74, 0x68, 0x1d, 0xce, 0x06, 0x20, 0x00, 0x3d, 0x0a,
  0xf1, 0xb0, 0xeb, 0xd8, 0xc8, 0x06, 0x64, 0x18, 0x02, 0x65, 0xa2, 0x49, 0x5f, 0x9a, 0x4d, 0xee, 0x6e, 0xd6, 0xe2, 0x94,
  0xfd, 0x77, 0xb3, 0x6a, 0x89, 0xec, 0xef, 0x64, 0x10, 0x2e, 0x37, 0xaa, 0x8b, 0x28, 0x59, 0x82, 0xb6, 0x3d, 0xbe, 0x5a,
  0x9a, 0x64, 0xc7, 0x2a, 0x04, 0xe6, 0x0a, 0x15, 0x3d, 0x72, 0x1e, 0x31, 0xa5, 0x25, 0x2b, 0x88, 0x00, 0x46, 0x4c, 0xb6,
  0x8f, 0x4c, 0xd8, 0x0e, 0xdd, 0x60, 0x72, 0x78, 0x68, 0xc3, 0x0f, 0x30, 0xea, 0xbc, 0xe5, 0x8b, 0xe7, 0x52, 0xe0, 0xf3,
  0xb8, 0x0b, 0x53, 0xe3, 0x0e, 0x6c, 0x66, 0xa5, 0xb4, 0x23, 0x69, 0xe4, 0x11, 0x11, 0xb6, 0xa6, 0x3d, 0x49, 0x2e, 0x2a,
  0xb3, 0x20, 0x69, 0x4b, 0x4a, 0x2b, 0x93, 0x35, 0x29, 0x26, 0xa9, 0xd8, 0x00, 0x27, 0x35, 0xcc, 0x81, 0x21, 0xc0, 0x2e,
  0xe4, 0xc7, 0x2c, 0xd6, 0x09, 0x13, 0x12, 0xeb, 0xcf, 0x5f, 0x67, 0x42, 0x32, 0x66, 0x7a, 0x00, 0xaf, 0xb2, 0x40, 0xc6,
  0x0c, 0xa5, 0x62, 0x4a, 0x01, 0x65, 0xbe, 0x9c, 0x31, 0x59, 0x43, 0xbe, 0xb0, 0xc9, 0x67, 0x17, 0x11, 0xa6, 0x5d, 0x3d,
  0xfd, 0x21, 0x5a, 0x15, 0x44, 0x78, 0x69, 0xa5, 0xca, 0x86, 0x95, 0x63, 0x2c, 0xca, 0xc7, 0x51, 0xc5, 0x58, 0x60, 0x5c,
  0x85, 0x5a, 0x11, 0xa7, 0x69, 0x1f, 0x9d, 0x3e, 0xc3, 0x71, 0x86, 0xb3, 0x42, 0x6e, 0x63, 0x0b, 0x5c, 0xc5, 0xbe, 0x35,
  0x5a, 0x47, 0x0b, 0x8d, 0x9e, 0x29, 0x60, 0xbb, 0x41, 0x4a, 0xe7, 0xb2, 0x66, 0xed, 0xbb, 0x1f, 0x67, 0x51, 0x29, 0x7e,
  0x4a, 0x4e, 0x73, 0xa9, 0xd3, 0x9d, 0x77, 0x39, 0xcb, 0xb5, 0x9f, 0xae, 0x70, 0x56, 0x30, 0xb6, 0xcd, 0xd9, 0x48, 0x8a,
  0xb0, 0xc7, 0x4d, 0xa1, 0xf7, 0x00, 0xc8, 0xc3, 0x82, 0x6d, 0x78, 0xf4, 0x17, 0x8d, 0x35, 0xe4, 0x47, 0x01, 0xc9, 0xcd,
  0x5b, 0xd1, 0x5e, 0x51, 0xa7, 0x4b, 0xcb, 0x0f, 0x50, 0xc9, 0xdb, 0xd5, 0x52, 0x1e, 0x27, 0x33, 0xa4, 0xb1, 0x03, 0xfe,
  0x48, 0x2b, 0xa9, 0x33, 0x35, 0x40, 0x09, 0x28, 0xf3, 0x0b, 0xf6, 0x8e, 0x0e, 0x88, 0x6a, 0xab, 0xa6, 0x5c, 0xf6, 0x18,
  0x79, 0x99, 0x09, 0x91, 0x53, 0x59, 0xd7, 0xa4, 0x30, 0x79, 0x68, 0xb3, 0x2e, 0x86, 0xc6, 0xe1, 0x53, 0x03, 0xd9, 0x68,
  0x96, 0x37, 0x16, 0xd8, 0xc7, 0x8d, 0x63, 0x40, 0xea, 0x2a, 0x97, 0x03, 0x64, 0x71, 0xe8, 0x1a, 0xc9, 0xe1, 0xcf, 0x2b,
  0x41, 0xb3, 0x9e, 0x73, 0xf4, 0xba, 0x23, 0x0e, 0xef, 0x2e, 0x90, 0x54, 0x1e, 0xb3, 0x41, 0x94, 0x5f, 0x79, 0xda, 0x8c,
  0x05, 0xf9, 0x62, 0x7a, 0xaa, 0xa0, 0xaf, 0xd9, 0xf7, 0xe5, 0xc2, 0x71, 0xd0, 0x1b, 0x07, 0x01, 0xdc, 0x55, 0x46, 0x56,
  0x23, 0x3c, 0x44, 0x2e, 0xce, 0x4c, 0x27, 0xb3, 0xa3, 0x0d, 0x38, 0xeb, 0x81, 0xee, 0x67, 0xad, 0x91, 0x7b, 0x37, 0xe2,
  0x63, 0x91, 0x51, 0x64, 0xeb, 0x14, 0x91, 0x61, 0x5b, 0x11, 0x17, 0x57, 0x24, 0x5d, 0x5a, 0xe1, 0x42, 0x90, 0x9b, 0x20,
  0x85, 0x1a, 0xcb, 0x8c, 0x53, 0x60, 0x75, 0xec, 0x6f, 0x65, 0xda, 0xad, 0xc3, 0x90, 0x2c, 0xa1, 0x2b, 0xca, 0x80, 0xc1,
  0x14, 0x5f, 0x36, 0x82, 0x69, 0x92, 0x23, 0x8c, 0x2e, 0x55, 0xa0, 0xc7, 0x04, 0x19, 0xcd, 0xbb, 0xfa, 0xbe, 0xb2, 0x77,
  0x17, 0x1e, 0xbc, 0x93, 0x57, 0x3a, 0x9d, 0x30, 0xf7, 0xf2, 0xab, 0x00, 0xe7, 0xbc, 0x86, 0x17, 0x50, 0x02, 0x66, 0x85,
  0x4e, 0x3e, 0xf4, 0x0d, 0xa9, 0x2b, 0x02, 0x05, 0xcf, 0x43, 0x83, 0x21, 0xcb, 0x69, 0xa2, 0xe8, 0xc1, 0x4c, 0x9e, 0x56,
  0x20, 0x93, 0xe6, 0xa0, 0x80, 0xb5, 0xb3, 0x3d, 0x5d, 0xac, 0x91, 0xbc, 0xfc, 0xc6, 0xa6, 0xcc, 0xa8, 0x32, 0xb9, 0xab,
  0xb3, 0x4c, 0x76, 0x03, 0xd4, 0xdd, 0x57, 0x64, 0xd2, 0x59, 0x79, 0xc0, 0x5d, 0xab, 0x6f, 0xdf, 0xbe, 0x7c, 0x5e, 0xb3,
  0x88, 0xfc, 0x54, 0x16, 0x65, 0xf9, 0x45, 0xb0, 0x3a, 0xa7, 0x84, 0xd3, 0xed, 0x23, 0xd2, 0x50, 0xd1, 0xa3, 0xb9, 0x00,
  0x5d, 0x74, 0x72, 0x04, 0x2b, 0x58, 0x6c, 0x9a, 0x38, 0x74, 0x4c, 0x12, 0x80, 0xe8, 0x99, 0xe3, 0x5f, 0x96, 0xc1, 0xa8,
  0x42, 0x62, 0x77, 0xa5, 0xcf, 0xda, 0x00, 0x31, 0xb5, 0xae, 0x39, 0x40, 0x60, 0x7a, 0x8d, 0xb4, 0x28, 0x59, 0xdb, 0x31,
  0x9e, 0x2e, 0x80, 0x6e, 0x89, 0x1c, 0x48, 0x01, 0x26, 0x1d, 0xc3, 0x57, 0x05, 0x32, 0x9b, 0xaa, 0x05, 0xac, 0x33, 0x32,
  0x65, 0x52, 0x25, 0x24, 0xe6, 0x15, 0x29, 0x13, 0x29, 0xd6, 0x7f, 0xd1, 0x59, 0x67, 0xb5, 0x01, 0xca, 0x8e, 0x3a, 0xab,
  0xae, 0xbf, 0x2d, 0x77, 0x34, 0x63, 0x24, 0xf3, 0x3b, 0xea, 0x57, 0x19, 0x27, 0x2f, 0x65, 0x6c, 0x3e, 0xce, 0xa2, 0x05,
  0x10, 0x26, 0x78, 0xaa, 0x49, 0x4b, 0xbe, 0x5b, 0x77, 0xb0, 0x64, 0x44, 0x72, 0x35, 0x28, 0x96, 0xac, 0x86, 0xac, 0xd9,
  0x6d, 0xab, 0x07, 0x48, 0x6b, 0x79, 0x6d, 0x0e, 0xd8, 0x77, 0xd8, 0x00, 0xef, 0x3b, 0x3c, 0xa6, 0x77, 0x53, 0xb8, 0xe9,
  0xac, 0x52, 0x1a, 0x3a, 0x8d, 0xef, 0x72, 0xb0, 0x45, 0x2f, 0xff, 0x0f, 0x3c, 0xd6, 0x22, 0xba, 0x39, 0xe8, 0x50, 0x8b,
  0x51, 0xf6, 0x1b, 0x1d, 0x69, 0xb9, 0x43, 0x78, 0x3f, 0x76, 0x2f, 0x51, 0xf0, 0xc0, 0xa8, 0x7b, 0x33, 0x9d, 0xd8, 0x57,
  0x1c, 0xb7, 0x2e, 0xda, 0x75, 0xdf, 0x58, 0x4c, 0xd1, 0xc3, 0x9b, 0xa5, 0x72, 0xa5, 0x05, 0x4b, 0x22, 0xfe, 0xa7, 0x7e,
  0x7a, 0x65, 0xe2, 0x4b, 0x25, 0x94, 0x67, 0xf9, 0x30, 0xc8, 0x34, 0x4a, 0xc6, 0x50, 0xa7, 0xf4, 0x10, 0x57, 0x50, 0xf9,
  0x31, 0xc5, 0x14, 0x74, 0x80, 0x0c, 0x15, 0xb6, 0x0d, 0xca, 0x9c, 0xca, 0x38, 0x48, 0x21, 0x41, 0x9a, 0x41, 0x30, 0xe2,
  0xb3, 0xc0, 0x2c, 0x9e, 0xde, 0x59, 0xa7, 0x4a, 0xe7, 0x77, 0x90, 0x4a, 0x95, 0x05, 0x47, 0x16, 0xeb, 0xd2, 0xef, 0xdf,
  0xe6, 0x40, 0x9f, 0x19, 0xe6, 0x6f, 0x5b, 0x47, 0xe2, 0x9f, 0x05, 0xf1, 0xd7, 0x42, 0x5c, 0xc1, 0xd9, 0x1a, 0xc0, 0xd6,
  0xd3, 0x82, 0x87, 0x2b, 0x00, 0xb0, 0xa9, 0xe6, 0x0b, 0xd2, 0x77, 0xac, 0x11, 0x34, 0x0e, 0x2c, 0x4d, 0xe3, 0x5b, 0x31,
  0x54, 0x32, 0xda, 0x00, 0x80, 0xd0, 0xb5, 0x0b, 0xd2, 0xe7, 0x1a, 0x8d, 0x32, 0x74, 0x3a, 0x53, 0x99, 0x60, 0xa8, 0x79,
  0xb6, 0xe1, 0xb2, 0x5c, 0x21, 0xcf, 0x86, 0x84, 0xb1, 0xa4, 0x79, 0xbe, 0x1e, 0x83, 0x6d, 0x9c, 0x09, 0x29, 0x0c, 0xc6,
  0x6e, 0x1e, 0x18, 0xc1, 0x28, 0xc2, 0x75, 0x31, 0x85, 0x23, 0x05, 0xe5, 0x01, 0x08, 0x0f, 0x16, 0xaa, 0x10, 0x12, 0xc2,
  0x1a, 0x42, 0x39, 0x84, 0xf2, 0x1c, 0xe0, 0x5f, 0xf1, 0x90, 0xc8, 0x8c, 0xb4, 0x57, 0x9a, 0x5c, 0x5c, 0x9c, 0x63, 0x22,
  0x2e, 0x49, 0x32, 0x51, 0x4a, 0xdd, 0xe5, 0xd8, 0x5f, 0x05, 0xbe, 0x3c, 0x59, 0x20, 0x8f, 0x08, 0x23, 0x20, 0x67, 0x5e,
  0x12, 0x6d, 0xbe, 0x89, 0x09, 0x45, 0xeb, 0x48, 0xec, 0x71, 0x36, 0x1a, 0x38, 0xd3, 0x14, 0x0e, 0x96, 0x9e, 0xed, 0x41,
  0x39, 0x00, 0x30, 0x07, 0xd4, 0xf3, 0x4f, 0x64, 0x36, 0xa1, 0x48, 0x7c, 0x19, 0x84, 0x73, 0x75, 0x41, 0xa1, 0x80, 0x1a,
  0x9e, 0xa5, 0x8b, 0x7c, 0x6c, 0x84, 0x83, 0x86, 0x48, 0x6a, 0xa3, 0x73, 0xc4, 0x69, 0x81, 0xc1, 0x68, 0x0f, 0x8c, 0xc5,
  0x3d, 0x90, 0x48, 0x3a, 0xda, 0x5d, 0x76, 0x11, 0xd8, 0x50, 0x87, 0x6f, 0xd8, 0x7d, 0x2a, 0xb3, 0x0d, 0xc8, 0x91, 0xb3,
  0xcc, 0xce, 0x34, 0xa5, 0xe9, 0xbc, 0xf4, 0xf1, 0x36, 0x6c, 0x45, 0x43, 0x70, 0xbd, 0x84, 0x9a, 0x25, 0x80, 0x21, 0x23,
  0x4c, 0x96, 0xde, 0x27, 0x8c, 0x00, 0x52, 0x59, 0x06, 0xee, 0x42, 0x5d, 0x34, 0xc0, 0x16, 0x9a, 0x6d, 0x0a, 0x0f, 0x11,
  0xe7, 0x56, 0xc5, 0x24, 0x35, 0x4f, 0xd3, 0xcf, 0x5f, 0x41, 0x69, 0xee, 0x62, 0xbf, 0xb4, 0xdc, 0xfb, 0xbc, 0x77, 0x27,
  0xf1, 0xc1, 0x5c, 0x09, 0x59, 0x4e, 0x40, 0x55, 0x68, 0x6d, 0xf0, 0x64, 0x36, 0x44, 0x3e, 0x2f, 0x40, 0xcc, 0x05, 0x94,
  0xdb, 0xd4, 0x04, 0xcb, 0x36, 0x06, 0x3a, 0xb4, 0x10, 0xa7, 0x87, 0x15, 0xa1, 0x34, 0x79, 0xad, 0x51, 0x7e, 0x92, 0x07,
  0x17, 0xef, 0xa4, 0xba, 0x70, 0xfe, 0x30, 0x75, 0x96, 0x98, 0x15, 0x71, 0xff, 0x9b, 0x6c, 0xad, 0xb4, 0x79, 0xd3, 0x42,
  0x29, 0x36, 0x98, 0x9f, 0x03, 0x8f, 0x98, 0xbc, 0xee, 0x5e, 0xc3, 0xf3, 0x17, 0xd8, 0xb2, 0x8d, 0xd0, 0x88, 0x8c, 0x38,
  0x6c, 0xf1, 0x46, 0xe2, 0x1e, 0x8b, 0xd6, 0x52, 0x6d, 0x77, 0xec, 0x48, 0xe5, 0x08, 0xcf, 0xff, 0x28, 0xbb, 0x89, 0xb2,
  0x68, 0xf1, 0xb6, 0xd5, 0x21, 0xff, 0x05, 0x86, 0x02, 0x63, 0x8e, 0x07, 0xda, 0x0b, 0x2c, 0x70, 0xd1, 0x51, 0x5c, 0xe8,
  0x1b, 0x5c, 0xea, 0xcb, 0x2d, 0x94, 0xfa, 0xc5, 0xe4, 0xfb, 0x9d, 0x66, 0x3a, 0x36, 0x6c, 0xd0, 0x69, 0x26, 0x52, 0xcb,
  0x11, 0xe5, 0xb6, 0x39, 0x91, 0x32, 0x15, 0xc4, 0xcc, 0xf9, 0x92, 0x10, 0x69, 0xb3, 0x1c, 0x8e, 0xf0, 0x32, 0x12, 0x14,
  0x8e, 0x42, 0x4e, 0x3f, 0xa1, 0xbb, 0x8b, 0x54, 0x03, 0x77, 0x74, 0x8c, 0x6b, 0x00, 0xf4, 0xd5, 0x38, 0x83, 0x02, 0xc7,
  0xb8, 0x51, 0xd8, 0x36, 0xc6, 0x76, 0xeb, 0x8b, 0xc6, 0x78, 0xb7, 0x91, 0xa6, 0x07, 0xc3, 0x0d, 0x8c, 0x97, 0x7b, 0xd6,
  0xea, 0x8c, 0xcc, 0x57, 0xce, 0xfa, 0x23, 0x2d, 0x83, 0xfb, 0xdf, 0xfa, 0x78, 0xf8, 0x97, 0x6b, 0x34, 0x1a, 0x32, 0x5b,
  0xdc, 0x8a, 0xc6, 0x5e, 0x14, 0x16, 0x00, 0x6d, 0x15, 0x0b, 0x0e, 0xeb, 0x14, 0xd8, 0xeb, 0xb8, 0x25, 0x3e, 0x42, 0x45,
  0x3b, 0xe7, 0x18, 0x50, 0xf7, 0x58, 0x1d, 0x3b, 0x9f, 0xe9, 0xd9, 0xbb, 0x80, 0xfa, 0x05, 0x94, 0xce, 0x0a, 0x48, 0xcf,
  0x05, 0x93, 0x7c, 0xee, 0x02, 0x44, 0x0c, 0xa0, 0x61, 0x2b, 0x8a, 0xf4, 0x94, 0x07, 0x9d, 0xd0, 0x4d, 0xa7, 0xe2, 0xa0,
  0x9b, 0x0e, 0xb5, 0xbd, 0x5d, 0x8b, 0x41, 0xd6, 0xa5, 0x93, 0x06, 0xde, 0x3c, 0xfd, 0xa5, 0x4e, 0x29, 0xa5, 0x29, 0xbf,
  0x2d, 0x59, 0xfb, 0x36, 0x61, 0x30, 0xa7, 0xdc, 0xa0, 0x57, 0xc0, 0xf2, 0xb7, 0x6b, 0x15, 0x63, 0x90, 0xda, 0x07, 0xa3,
  0x6d, 0x12, 0xa3, 0x0f, 0x20, 0x4b, 0x30, 0xc7, 0x4e, 0x84, 0x03, 0xbc, 0xc2, 0x34, 0x9b, 0x0c, 0x14, 0x18, 0x23, 0xaa,
  0x2e, 0x50, 0x5b, 0x33, 0x3b, 0x92, 0x0c, 0x7d, 0x57, 0x8b, 0x20, 0xa6, 0xbb, 0x40, 0xa3, 0x87, 0x1c, 0xab, 0x76, 0x99,
  0xac, 0x25, 0xfe, 0xda, 0xc2, 0x82, 0x45, 0xd2, 0x0f, 0xc9, 0x44, 0x45, 0x7b, 0x45, 0xa1, 0xf0, 0xe2, 0xf3, 0x1b, 0xd1,
  0xdb, 0x6b, 0x80, 0x1a, 0xdf, 0x15, 0xb1, 0x97, 0x9f, 0x3a, 0x78, 0xe7, 0x09, 0x2c, 0x26, 0xd5, 0x07, 0xe1, 0x8b, 0x72,
  0x5f, 0x15, 0xb0, 0xd0, 0x32, 0x94, 0xf4, 0x71, 0xe9, 0x37, 0x99, 0xd1, 0xa0, 0x6e, 0x95, 0xd5, 0xb0, 0xd1, 0x6f, 0xc7,
  0x9e, 0x45, 0xa9, 0x84, 0x0b, 0x55, 0x5b, 0x02, 0xe6, 0xc5, 0xc6, 0x8b, 0xa5, 0xee, 0x91, 0x0a, 0x11, 0xb0, 0xd4, 0x69,
  0xf6, 0xa2, 0xa2, 0xdc, 0x64, 0x25, 0x2a, 0xc5, 0x0c, 0x5a, 0xbd, 0x68, 0xf8, 0xdb, 0xe5, 0xfa, 0x70, 0x31, 0xe8, 0x19,
  0xd6, 0x71, 0xb0, 0x4e, 0xfc, 0xbf, 0x4a, 0x9b, 0xa0, 0x61, 0x3f, 0x87, 0x11, 0x48, 0x39, 0x87, 0x62, 0x30, 0xbe, 0x81,
  0x88, 0xa3, 0x1a, 0xce, 0xc4, 0x13, 0x21, 0xc6, 0xcf, 0xd2, 0x79, 0x5b, 0xf2, 0x19, 0xa1, 0x5f, 0x95, 0x67, 0xab, 0x67,
  0x1b, 0xc2, 0xd2, 0x52, 0x61, 0x60, 0x33, 0xba, 0x50, 0x41, 0xa8, 0x31, 0x3c, 0xcc, 0x83, 0x0a, 0x07, 0xa5, 0xc1, 0xe5,
  0x74, 0x40, 0xdc, 0x3c, 0xc2, 0x88, 0xb5, 0x10, 0x8c, 0x16, 0x57, 0x59, 0x09, 0xf0, 0x63, 0xd3, 0xf9, 0x29, 0xd2, 0x0e,
  0x64, 0x3a, 0x8b, 0x48, 0xf8, 0xf3, 0x51, 0xa1, 0xc4, 0xfc, 0x42, 0x77, 0x93, 0x77, 0xb2, 0x13, 0x3e, 0x40, 0xdc, 0xb1,
  0xc3, 0xc8, 0x14, 0xe8, 0x9f, 0x65, 0xca, 0x7c, 0x85, 0x54, 0x9f, 0xdf, 0xd6, 0x6a, 0x00, 0x4c, 0x72, 0x35, 0x7c, 0x64,
  0x8a, 0x29, 0x62, 0x23, 0x38, 0x32, 0x22, 0x9b, 0xb7, 0x51, 0xe4, 0x5b, 0x92, 0xe9, 0x75, 0x18, 0xd6, 0x17, 0xb8, 0xbe,
  0xab, 0x88, 0x0e, 0x08, 0x37, 0xd6, 0x40, 0xe2, 0x30, 0xcf, 0xd4, 0x02, 0x23, 0x50, 0x0f, 0x4c, 0xe2, 0xc0, 0xf6, 0x17,
  0xd9, 0x49, 0x63, 0xcd, 0x74, 0xf2, 0x2e, 0x2a, 0xba, 0x30, 0x56, 0xd0, 0x7e, 0x00, 0x44, 0x2a, 0x30, 0xd6, 0xbe, 0x01,
  0xb6, 0x34, 0x93, 0x99, 0x1e, 0x95, 0x5f, 0x4c, 0x45, 0x9a, 0xd9, 0xb4, 0xd1, 0xf8, 0x0e, 0xe1, 0x0d, 0x44, 0xdf, 0xbf,
  0xf5, 0x9e, 0x12, 0xcd, 0x8a, 0xad, 0x44, 0xbf, 0x1d, 0x0a, 0x05, 0x0e, 0x51, 0x6d, 0xd5, 0xd2, 0xb3, 0x2a, 0x2d, 0x41,
  0x39, 0xa4, 0x8c, 0xf9, 0x60, 0x4c, 0xde, 0x02, 0xea, 0x22, 0x2f, 0x92, 0xcc, 0xcb, 0xcb, 0x1e, 0x0e, 0x6e, 0x3a, 0xa9,
  0xd1, 0x88, 0x96, 0x96, 0x0c, 0x3c, 0x3f, 0x81, 0x06, 0x76, 0x25, 0x74, 0xdf, 0x48, 0x66, 0xa4, 0x68, 0x3a, 0x5a, 0x6e,
  0x03, 0xb1, 0xdd, 0xd2, 0x0e, 0x3d, 0x2c, 0x3f, 0x16, 0x47, 0x02, 0x8c, 0x92, 0xc2, 0x8c, 0xf7, 0x15, 0x66, 0x3a, 0xd4,
  0xd7, 0x19, 0xd4, 0x24, 0x9a, 0x1c, 0x60, 0xa9, 0xd3, 0x20, 0x98, 0x35, 0xd2, 0x19, 0x8d, 0x7d, 0xab, 0x7d, 0x76, 0xfa,
  0x03, 0xe8, 0xab, 0xf3, 0xed, 0x86, 0x44, 0x15, 0x46, 0x47, 0x10, 0x38, 0x44, 0xd6, 0x10, 0x96, 0x0a, 0xd6, 0xa9, 0x2c,
  0x00, 0x92, 0x81, 0x54, 0xcb, 0xc8, 0xbe, 0x25, 0x52, 0xea, 0xb3, 0xc9, 0x05, 0x6d, 0x28, 0x08, 0x32, 0x68, 0x29, 0xe0,
  0xf0, 0x27, 0xa6, 0x80, 0x0c, 0x70, 0xb4, 0xd5, 0x51, 0x66, 0x71, 0xce, 0x7a, 0xc6, 0xa9, 0xaf, 0xe4, 0x59, 0x6a, 0x67,
  0xb3, 0x5d, 0xa1, 0x45, 0x63, 0xcc, 0x82, 0x92, 0x0a, 0xf8, 0xe6, 0x93, 0x1c, 0x30, 0xbe, 0xc5, 0xa2, 0x31, 0xbb, 0x08,
  0xd7, 0xec, 0x61, 0x6e, 0x7e, 0x7d, 0x10, 0x43, 0x7a, 0x1b, 0xcf, 0x1d, 0xd2, 0x72, 0x1e, 0x76, 0xbc, 0xd8, 0x48, 0x56,
  0x6c, 0xf5, 0xc2, 0xd0, 0xed, 0x20, 0xc8, 0x25, 0x64, 0x96, 0x0d, 0x67, 0x29, 0x52, 0x19, 0x6b, 0x87, 0x56, 0x45, 0x5c,
  0x57, 0x3d, 0x77, 0x3f, 0x02, 0xe7, 0x04, 0x44, 0x40, 0xa2, 0x07, 0x0d, 0xe5, 0x1d, 0x7d, 0xdf, 0xef, 0xb5, 0xcd, 0x73,
  0x10, 0x8f, 0x36, 0xc8, 0x2a, 0xa6, 0x3e, 0xae, 0x21, 0xc5, 0x99, 0x03, 0x7b, 0xce, 0x67, 0xd2, 0xc1, 0xa3, 0x64, 0x78,
  0x1b, 0x64, 0x5a, 0x03, 0x0f, 0x19, 0xca, 0xe8, 0x2b, 0x74, 0x6d, 0xd1, 0xb5, 0x3b, 0x91, 0xe7, 0x6b, 0xfc, 0x30, 0xa6,
  0xc4, 0x21, 0x50, 0x77, 0x9f, 0x47, 0x6d, 0xdf, 0x3a, 0xf1, 0x2d, 0x45, 0x25, 0xde, 0x34, 0x71, 0xf5, 0x90, 0xd5, 0x95,
  0xb6, 0x47, 0x48, 0xa5, 0xc6, 0xf7, 0xdc, 0xc3, 0xa1, 0x64, 0x21, 0x65, 0x43, 0x56, 0xd7, 0x6a, 0xe7, 0xd7, 0xf6, 0xe9,
  0x4a, 0xda, 0x1d, 0x8d, 0xd8, 0xb3, 0x46, 0xcc, 0xb9, 0x15, 0x96, 0xd0, 0x15, 0x4e, 0x15, 0x4d, 0x44, 0x9a, 0x2d, 0x9b,
  0x4e, 0xfa, 0x72, 0xfc, 0xc4, 0x56, 0x1c, 0xff, 0x43, 0x79, 0x5e, 0x65, 0x37, 0xf4, 0xc4, 0xc9, 0x22, 0xb4, 0x2a, 0x85,
  0x98, 0xd2, 0x70, 0xee, 0xcd, 0x80, 0x60, 0x69, 0x89, 0x7b, 0xe4, 0x81, 0xe5, 0x0b, 0x2f, 0x56, 0xd7, 0x55, 0xa8, 0x6c,
  0xe1, 0xea, 0x04, 0x33, 0x65, 0x24, 0x96, 0x11, 0x90, 0x22, 0x3a, 0xaf, 0xa1, 0x1f, 0xd7, 0xb6, 0xc5, 0x40, 0x8a, 0xd9,
  0xe2, 0x21, 0x52, 0xb7, 0xe3, 0xfc, 0x3c, 0x4b, 0xa2, 0x29, 0x10, 0x8a, 0x76, 0xab, 0xdd, 0xc7, 0x57, 0xcf, 0x41, 0xdd,
  0xa3, 0xa8, 0x3d, 0x64, 0xc0, 0x74, 0x5d, 0xc2, 0xbb, 0x8d, 0xb7, 0x8a, 0x97, 0x28, 0xa0, 0x6c, 0x9c, 0x3f, 0x76, 0x9b,
  0x6e, 0xdf, 0x79, 0xe3, 0xda, 0xda, 0x35, 0x2f, 0x03, 0xa7, 0x45, 0xfc, 0x8f, 0xbe, 0x0b, 0x3c, 0x5d, 0x52, 0x58, 0x13,
  0xfd, 0x62, 0xf0, 0xf5, 0xc1, 0x29, 0x53, 0x49, 0x48, 0x0e, 0xfc, 0x30, 0xb1, 0x6e, 0xf5, 0xef, 0xb7, 0xe1, 0x82, 0xd8,
  0x10, 0x8f, 0xb2, 0x12, 0xe7, 0x41, 0x74, 0xec, 0xbc, 0xc1, 0x10, 0x0c, 0xbe, 0x1d, 0x02, 0xe9, 0x6a, 0x53, 0x77, 0x68,
  0xc8, 0x95, 0x53, 0x04, 0x57, 0x1e, 0x50, 0x76, 0xfc, 0x8d, 0x77, 0x85, 0x2d, 0xd3, 0xc4, 0x1b, 0xc2, 0x59, 0x7b, 0x0e,
  0x72, 0xce, 0xec, 0x53, 0xc3, 0x5b, 0x87, 0x54, 0x58, 0x77, 0x97, 0x18, 0xe7, 0xe5, 0x11, 0xb0, 0xf1, 0x18, 0x1b, 0x9b,
  0x25, 0xe9, 0x21, 0x68, 0x2d, 0xcc, 0x15, 0x6b, 0x2f, 0xc2, 0xe9, 0x06, 0xef, 0x24, 0x9a, 0xf1, 0xfc, 0x48, 0xe0, 0x22,
  0x22, 0xe4, 0x73, 0xda, 0x0e, 0x4a, 0x91, 0x85, 0x87, 0xd2, 0x81, 0x70, 0x39, 0x6f, 0x5e, 0x3c, 0x7d, 0xfe, 0xfa, 0x45,
  0xd1, 0xa5, 0x2a, 0xd1, 0x26, 0x3c, 0xa7, 0x28, 0xc2, 0xdc, 0xf4, 0xe9, 0xb6, 0xee, 0xf3, 0x40, 0x24, 0xf7, 0x44, 0xa2,
  0x0f, 0xca, 0xe8, 0x5f, 0xfe, 0x72, 0x43, 0x87, 0xce, 0xbd, 0x4d, 0x74, 0xc1, 0x63, 0x21, 0xf0, 0xfc, 0x06, 0x0c, 0xe8,
  0x5f, 0x44, 0xbd, 0x70, 0x09, 0xd3, 0xb8, 0x24, 0xe7, 0x73, 0x8c, 0x65, 0x7b, 0xdf, 0x6f, 0x82, 0xe0, 0xaf, 0xcc, 0x75,
  0xd0, 0x3b, 0xbd, 0x4d, 0x2e, 0xa2, 0x4d, 0x8c, 0x0c, 0x83, 0xbc, 0x36, 0x09, 0x28, 0xc4, 0xe9, 0xb8, 0x05, 0x04, 0x1c,
  0x91, 0x07, 0x95, 0x09, 0x2a, 0xcf, 0xd2, 0x36, 0x83, 0x14, 0x4d, 0x42, 0x4a, 0x61, 0xa2, 0x1b, 0x6e, 0x73, 0x60, 0xa5,
  0xc6, 0x42, 0x66, 0x5e, 0xde, 0x1c, 0x36, 0x25, 0x26, 0x9d, 0xf1, 0xd9, 0x06, 0x40, 0x0d, 0xa1, 0x89, 0x5f, 0xb3, 0xfa,
  0x67, 0x08, 0x05, 0x27, 0xee, 0xd1, 0xc2, 0x84, 0xc9, 0xbd, 0x8e, 0x1c, 0x51, 0xb0, 0x03, 0x27, 0x40, 0x04, 0x5c, 0xe1,
  0xfe, 0xd7, 0x54, 0x0c, 0x6f, 0x85, 0xfd, 0xc1, 0xf7, 0x70, 0x7e, 0x63, 0x1e, 0x62, 0xe4, 0x5d, 0x2e, 0x52, 0x35, 0x64,
  0xf8, 0xa6, 0x85, 0x18, 0xd3, 0x81, 0x7b, 0xfc, 0x97, 0xbf, 0x18, 0xf2, 0x9e, 0x27, 0x73, 0x88, 0x8b, 0x9f, 0x20, 0xa4,
  0x05, 0x52, 0xb6, 0x94, 0xa2, 0x0c, 0x8c, 0x11, 0xb6, 0x6e, 0xb4, 0x08, 0x29, 0xb9, 0x97, 0x68, 0x25, 0x9e, 0x6d, 0xc2,
  0x75, 0x02, 0xe4, 0x1f, 0x44, 0xbb, 0x38, 0x71, 0x1e, 0x4e, 0xa0, 0x91, 0x53, 0x3f, 0x9a, 0x6d, 0xe9, 0xf2, 0x1c, 0xd8,
  0xac, 0x2f, 0x38, 0xb1, 0xc0, 0xf7, 0x37, 0x2f, 0xfd, 0x6a, 0xe8, 0xd7, 0xc6, 0xf7, 0x16, 0x81, 0x4c, 0x5d, 0x30, 0xb9,
  0xdd, 0xd5, 0x31, 0x69, 0x2e, 0x8b, 0xaa, 0xf2, 0x09, 0xb9, 0x17, 0xfe, 0xa6, 0x91, 0xd0, 0xd1, 0x99, 0x49, 0xab, 0x8e,
  0xcc, 0xe7, 0x69, 0x32, 0x69, 0xbc, 0x84, 0x7a, 0xb8, 0x24, 0xf4, 0xe2, 0x17, 0x20, 0x4c, 0x80, 0x52, 0x93, 0x15, 0x48,
  0x10, 0x75, 0x1e, 0xab, 0xf1, 0x4a, 0xc4, 0x9d, 0xa0, 0xb3, 0x7a, 0x52, 0xc1, 0xdb, 0x43, 0x2a, 0xf5, 0x29, 0xa8, 0xdf,
  0x78, 0xcf, 0x51, 0xe0, 0x4f, 0xe8, 0xc2, 0xb8, 0xba, 0x94, 0xee, 0xdf, 0x00, 0xec, 0x61, 0x05, 0x57, 0xd0, 0x17, 0x0f,
  0x0e, 0x4b, 0xbd, 0x45, 0xe7, 0x31, 0xac, 0x07, 0xbc, 0x9c, 0x26, 0x6f, 0x17, 0x11, 0xaa, 0xf6, 0x50, 0x78, 0xd2, 0x70,
  0xeb, 0xa9, 0xc5, 0xe8, 0x79, 0xb8, 0x49, 0x6e, 0xb8, 0xb5, 0xb1, 0x80, 0xc2, 0xf3, 0x97, 0x4f, 0xff, 0xf0, 0xd3, 0xcf,
  0x6f, 0xdf, 0xbd, 0x7c, 0xf6, 0xf6, 0xe3, 0xcb, 0x9f, 0xde, 0xbd, 0x78, 0xf3, 0xc7, 0xa7, 0xaf, 0x3e, 0xbe, 0x7e, 0x3b,
  0xc1, 0x2b, 0xa0, 0x5b, 0xb2, 0x90, 0xc8, 0xee, 0x21, 0x0d, 0x05, 0x13, 0xd4, 0x1b, 0xe1, 0xa1, 0x5a, 0x93, 0x05, 0xf4,
  0x40, 0x77, 0x32, 0x24, 0xc6, 0x93, 0xa7, 0x9b, 0x8d, 0x77, 0x53, 0xed, 0xd6, 0x9a, 0x78, 0x73, 0x74, 0x15, 0x27, 0x29,
  0x00, 0xaa, 0x97, 0xc5, 0x8c, 0xc4, 0x2b, 0x11, 0xf8, 0x40, 0x43, 0xcd, 0x44, 0xe7, 0x43, 0x6f, 0xe9, 0x57, 0xd9, 0xd9,
  0x14, 0x4f, 0x11, 0x73, 0x98, 0x2b, 0x1d, 0x3a, 0x9b, 0xbc, 0xbf, 0xe7, 0xdc, 0x7e, 0x0a, 0x6e, 0x46, 0x15, 0x44, 0xae,
  0x8f, 0x7c, 0x71, 0xcf, 0xc7, 0x76, 0x17, 0x40, 0x18, 0x26, 0xa3, 0x56, 0x9d, 0x84, 0xce, 0x51, 0x85, 0x36, 0x3d, 0x7f,
  0xac, 0xd4, 0x6f, 0x82, 0x78, 0x54, 0x69, 0x77, 0x1b, 0xe8, 0x06, 0xab, 0xd4, 0x57, 0xd1, 0xa8, 0xe2, 0xb6, 0xf9, 0x61,
  0x57, 0x97, 0xad, 0xb1, 0xfc, 0xf1, 0x11, 0xfe, 0x1f, 0x70, 0x53, 0xae, 0x6c, 0x8a, 0x8d, 0x29, 0x0e, 0x7f, 0xa1, 0xa6,
  0x7e, 0x5e, 0x71, 0x2b, 0xa0, 0xc2, 0x68, 0x2d, 0xa0, 0xb2, 0xf0, 0x91, 0xce, 0x52, 0x73, 0x03, 0x6d, 0xd9, 0xc0, 0x53,
  0x2d, 0x8f, 0x24, 0x7d, 0x2d, 0x69, 0x84, 0xc4, 0xde, 0x8f, 0x2c, 0x12, 0x73, 0x33, 0x1d, 0xd9, 0x8c, 0x88, 0x3b, 0xd1,
  0x54, 0xb8, 0xd2, 0x96, 0xf0, 0x68, 0xb7, 0x3e, 0x9c, 0xae, 0x6c, 0xe7, 0x95, 0x71, 0xdc, 0x5b, 0xb4, 0xf1, 0x2a, 0xc2,
  0xe6, 0xb0, 0x15, 0x3a, 0x18, 0xae, 0xb5, 0x83, 0x82, 0xdb, 0x47, 0x50, 0x58, 0x3f, 0x52, 0xe0, 0x0e, 0xb7, 0xd5, 0x93,
  0x6d, 0x3d, 0x27, 0x45, 0x58, 0x07, 0xf3, 0x73, 0x50, 0x6d, 0x8f, 0x9d, 0x25, 0x30, 0xf8, 0x0b, 0x6e, 0xef, 0x35, 0xfe,
  0x84, 0x57, 0xd0, 0x84, 0x3e, 0x3a, 0x50, 0x31, 0xb6, 0x40, 0x84, 0xb9, 0xbd, 0x7e, 0xda, 0x1e, 0x08, 0x9d, 0xf2, 0xd3,
  0xee, 0xde, 0x07, 0x85, 0x72, 0x0a, 0xab, 0xff, 0x39, 0xb8, 0x01, 0x1c, 0xa8, 0xe0, 0x8b, 0x8f, 0x6c, 0xa9, 0xfc, 0x28,
  0x4e, 0x5e, 0x57, 0xea, 0xc6, 0x5b, 0xb2, 0xf9, 0x64, 0xde, 0x01, 0x66, 0x67, 0xde, 0x48, 0x33, 0x6a, 0x45, 0x75, 0xa5,
  0x72, 0xf2, 0x4c, 0xde, 0xdf, 0x86, 0x3e, 0x60, 0x14, 0xc6, 0xc9, 0x8d, 0x2a, 0x46, 0x5e, 0x1a, 0x98, 0x08, 0x7e, 0x73,
  0xc5, 0xb7, 0x43, 0x53, 0xc9, 0x88, 0x6a, 0x6d, 0x51, 0x2d, 0x9f, 0xbc, 0x25, 0x57, 0xfe, 0x83, 0xb1, 0xe7, 0xe4, 0xad,
  0x2c, 0x93, 0xf7, 0xad, 0xba, 0x5b, 0x6f, 0xd7, 0x3b, 0x1f, 0x9a, 0x4b, 0x6f, 0x5d, 0x45, 0xca, 0x56, 0x85, 0x86, 0xb9,
  0xd9, 0xdf, 0x19, 0x4f, 0x1e, 0xc2, 0x8b, 0xc7, 0xee, 0xee, 0xf7, 0x5d, 0x0d, 0x76, 0xe2, 0x7c, 0xbb, 0x62, 0x79, 0x37,
  0x88, 0x67, 0xd5, 0xcb, 0xda, 0x2d, 0xa7, 0x08, 0x73, 0xde, 0x26, 0x28, 0xac, 0x55, 0x2f, 0xcf, 0xce, 0x2a, 0x95, 0x5a,
  0x53, 0xc4, 0x19, 0x54, 0x8f, 0xdf, 0x3f, 0x7a, 0x72, 0x7a, 0x54, 0xf9, 0x70, 0x7c, 0x5e, 0x9f, 0x61, 0xc3, 0x95, 0x47,
  0x95, 0x51, 0x85, 0xf2, 0x13, 0x00, 0xec, 0x9e, 0xe0, 0xef, 0x45, 0x82, 0x3f, 0x4f, 0xf1, 0xe7, 0x39, 0xfd, 0x3c, 0xc2,
  0x9f, 0xff, 0xb6, 0x8d, 0xf0, 0xe1, 0xa8, 0x72, 0x04, 0x0f, 0x0f, 0x3a, 0x27, 0xe3, 0xca, 0xee, 0xfd, 0xec, 0x43, 0xad,
  0xb6, 0x4b, 0xbb, 0x27, 0xd2, 0x59, 0x5d, 0xc6, 0xe7, 0xf5, 0xe8, 0xd3, 0x84, 0x34, 0x80, 0x5b, 0x9e, 0x5e, 0x32, 0x79,
  0x58, 0xad, 0xd0, 0xd7, 0x4a, 0x6d, 0x9c, 0x34, 0x93, 0xe0, 0x3a, 0x79, 0xc6, 0x17, 0x4e, 0x4e, 0xa0, 0x34, 0xbc, 0x21,
  0x86, 0x80, 0x89, 0x12, 0x27, 0x5c, 0xcc, 0xc1, 0x68, 0x1f, 0xa7, 0xf2, 0xb8, 0x1a, 0x7d, 0x3a, 0xab, 0x9c, 0x47, 0x91,
  0x0f, 0x23, 0x98, 0x7a, 0x3e, 0xd4, 0xa6, 0xcc, 0xe5, 0xb8, 0xfd, 0x41, 0xb8, 0xab, 0xa6, 0xb4, 0x1a, 0x9a, 0x4d, 0xe9,
  0x36, 0x10, 0x57, 0x59, 0xa2, 0x5a, 0x9b, 0x9c, 0xe6, 0x9b, 0xaf, 0xd4, 0x3b, 0xdd, 0x56, 0x0b, 0x86, 0xee, 0x91, 0x14,
  0xad, 0x26, 0x00, 0x52, 0x4e, 0x75, 0xbb, 0x59, 0xd4, 0x41, 0xa2, 0x05, 0x56, 0x20, 0x47, 0x9f, 0x5a, 0x0f, 0x88, 0x58,
  0x82, 0x5c, 0xb9, 0xa1, 0xe1, 0xf3, 0xbb, 0x6a, 0xad, 0x9e, 0x70, 0x67, 0xd9, 0x7e, 0xd3, 0x7a, 0x4d, 0x0f, 0xeb, 0x40,
  0x49, 0x68, 0xb8, 0xb9, 0x0c, 0x40, 0x90, 0xf0, 0x27, 0x93, 0x49, 0xe5, 0x17, 0xa0, 0xd5, 0x95, 0x33, 0xb7, 0x07, 0xd4,
  0x79, 0x34, 0x84, 0x3f, 0x30, 0x89, 0xcd, 0x8d, 0xe8, 0x74, 0x33, 0xf1, 0x38, 0xae, 0x28, 0xc0, 0xc0, 0x29, 0x1c, 0xd4,
  0x6d, 0xb3, 0xd9, 0x84, 0xfa, 0x75, 0x3e, 0xca, 0x3e, 0xd2, 0x5a, 0xe7, 0x37, 0xbb, 0xda, 0x18, 0x49, 0xb2, 0x4f, 0x8d,
  0xf8, 0xa2, 0xfa, 0xa6, 0xf9, 0x97, 0x38, 0x5a, 0x55, 0x6b, 0xbb, 0x19, 0x05, 0x60, 0xc1, 0x8a, 0x24, 0x17, 0x1b, 0x00,
  0x2d, 0xa5, 0xcc, 0xaa, 0xfe, 0xfe, 0x72, 0x45, 0xa9, 0x9f, 0xd2, 0x9b, 0x5f, 0x48, 0xe8, 0x7e, 0x78, 0x0b, 0xfd, 0xed,
  0x7e, 0xaf, 0xed, 0xc2, 0x79, 0xf5, 0xfe, 0xa6, 0x19, 0x7d, 0xfa, 0xfc, 0xd9, 0x6f, 0x32, 0xa3, 0xc3, 0x61, 0x53, 0x2e,
  0xad, 0x4a, 0x4d, 0x6f, 0xc8, 0x87, 0x59, 0x91, 0x79, 0xfc, 0xf3, 0xe7, 0xdf, 0xdf, 0x88, 0xfc, 0x78, 0x22, 0xe8, 0xa0,
  0xfa, 0xf0, 0x76, 0x23, 0x2a, 0xef, 0x6a, 0xbf, 0xd7, 0xc6, 0x02, 0x39, 0xfd, 0x74, 0x44, 0xd0, 0x4b, 0x6e, 0x32, 0x0c,
  0xb1, 0xc0, 0x37, 0x7a, 0xa9, 0xc8, 0xa6, 0x11, 0xe0, 0x3e, 0x9a, 0x71, 0xf0, 0x76, 0x13, 0x50, 0x77, 0xa5, 0xff, 0x85,
  0x0c, 0xda, 0x30, 0xfd, 0x26, 0xa2, 0x19, 0x55, 0x0c, 0x76, 0x74, 0xd6, 0x64, 0x01, 0x60, 0x35, 0x10, 0x87, 0xff, 0xad,
  0xed, 0x34, 0xec, 0x55, 0x01, 0x66, 0xb8, 0xcf, 0xea, 0x42, 0xe4, 0x87, 0x9d, 0x83, 0xe3, 0xbb, 0xff, 0x5e, 0x30, 0x72,
  0x11, 0x7c, 0x56, 0xd7, 0x52, 0xb6, 0xd5, 0xd5, 0x5d, 0x56, 0xf5, 0xf4, 0xae, 0xaf, 0x7a, 0x7a, 0x6b, 0x11, 0xfc, 0x44,
  0x4d, 0xa4, 0xf2, 0xa1, 0x29, 0x25, 0x52, 0xea, 0xa1, 0x56, 0x5b, 0x11, 0x42, 0x52, 0xbb, 0x63, 0x5d, 0x66, 0xc0, 0xf7,
  0x63, 0x25, 0xcb, 0xc0, 0x8c, 0x37, 0x37, 0x9c, 0x51, 0x2a, 0xda, 0x3c, 0x05, 0xf6, 0x5b, 0x69, 0xa2, 0x16, 0x0b, 0x3b,
  0x1a, 0x08, 0xf3, 0x0b, 0xd0, 0xd7, 0xaa, 0xd7, 0x93, 0xd3, 0x6b, 0x46, 0x71, 0xcc, 0x9d, 0xda, 0x64, 0x2b, 0x5a, 0xb5,
  0xc2, 0x77, 0xb6, 0x56, 0xea, 0xd7, 0xcd, 0x90, 0xb0, 0x8d, 0x74, 0xdf, 0xca, 0x63, 0xee, 0xbb, 0xb4, 0x7d, 0xbe, 0xd9,
  0xd7, 0xec, 0x41, 0xa0, 0x25, 0x37, 0x3a, 0xb9, 0x6e, 0xe2, 0xad, 0xbf, 0x78, 0x0f, 0x0d, 0x5d, 0xfc, 0x3b, 0xe1, 0x31,
  0x97, 0x8d, 0x82, 0xff, 0xad, 0x8d, 0x01, 0x98, 0xe2, 0xe7, 0x75, 0x13, 0x63, 0x37, 0x12, 0x20, 0x52, 0xc0, 0x9c, 0xb1,
  0xa4, 0x76, 0x2f, 0x37, 0x00, 0x0d, 0x35, 0x72, 0x58, 0xc6, 0x00, 0xe4, 0x1b, 0xe7, 0xba, 0x89, 0x17, 0xb6, 0x5c, 0x06,
  0x45, 0xa5, 0x6b, 0x88, 0xfb, 0xa8, 0xcf, 0x0a, 0x9f, 0x0b, 0xb6, 0xfc, 0x32, 0x09, 0x96, 0xd5, 0xca, 0x2c, 0xa6, 0xab,
  0x89, 0x2b, 0x44, 0x3c, 0xa9, 0x77, 0x82, 0x3a, 0x80, 0x43, 0xad, 0xcf, 0xa3, 0x47, 0xa9, 0x74, 0xf6, 0xe8, 0xd1, 0x7d,
  0x05, 0x18, 0x76, 0x9d, 0xd4, 0x0a, 0x6c, 0x1b, 0x63, 0x86, 0x87, 0x8f, 0x19, 0xc8, 0x56, 0xc4, 0x6a, 0x27, 0x8c, 0x32,
  0x67, 0x0f, 0xab, 0xfc, 0xa3, 0x36, 0x02, 0xa2, 0xa7, 0x5f, 0xae, 0x0b, 0xb3, 0xd1, 0x8a, 0x9f, 0x35, 0x41, 0x86, 0x05,
  0x94, 0x7f, 0xb9, 0x4a, 0x22, 0x5c, 0xf6, 0xb3, 0x66, 0xf5, 0x96, 0x4c, 0xf9, 0xa3, 0x8a, 0xe0, 0x6d, 0xd3, 0xe0, 0x02,
  0xe4, 0x80, 0x68, 0x03, 0x2f, 0x96, 0x28, 0xce, 0x57, 0x76, 0x40, 0xb1, 0xee, 0xb4, 0x6e, 0xd3, 0xc9, 0xe9, 0xb4, 0x29,
  0xad, 0x34, 0x48, 0x92, 0x14, 0x8e, 0x4f, 0x8d, 0x05, 0xac, 0xa7, 0x8f, 0x3c, 0xf6, 0xcf, 0x9f, 0x01, 0xf1, 0x75, 0xce,
  0x82, 0x47, 0xe4, 0x6e, 0xf8, 0x96, 0x64, 0xba, 0x78, 0xb8, 0x76, 0xab, 0x06, 0x22, 0x7f, 0x08, 0x89, 0xfb, 0x2c, 0xb3,
  0xac, 0x74, 0x3d, 0x34, 0xd5, 0xa9, 0xd4, 0xb9, 0xea, 0x18, 0x99, 0x41, 0x7a, 0x19, 0x33, 0x8c, 0x57, 0xaf, 0x01, 0x70,
  0xa8, 0xe8, 0x57, 0x2c, 0x57, 0xea, 0x82, 0x8f, 0x51, 0x15, 0x5c, 0x39, 0x96, 0x7a, 0x6a, 0x87, 0xb6, 0x43, 0xb2, 0x87,
  0xe8, 0x3b, 0xad, 0x7e, 0x56, 0x49, 0xaf, 0x77, 0xc6, 0x20, 0x2d, 0xbe, 0xdd, 0x19, 0xd8, 0x8c, 0xf5, 0xd6, 0xe7, 0x8a,
  0xc9, 0xe6, 0xb4, 0x2b, 0xa3, 0x25, 0x87, 0xa3, 0xd6, 0x0d, 0x1c, 0x3c, 0xd7, 0x70, 0x50, 0x34, 0xa2, 0x77, 0x8f, 0x9d,
  0x42, 0x77, 0xfc, 0x58, 0x8c, 0xbd, 0x26, 0xe4, 0x72, 0xcb, 0x00, 0x2c, 0x2c, 0x7d, 0x75, 0x97, 0xee, 0xf9, 0xdf, 0x11,
  0x0f, 0x43, 0x5f, 0x69, 0xb4, 0xe8, 0x83, 0xcc, 0x51, 0x47, 0x26, 0x4d, 0xda, 0x4d, 0x40, 0x44, 0x90, 0xa7, 0x19, 0x00,
  0x23, 0x47, 0x6d, 0x0a, 0x49, 0x62, 0x50, 0x63, 0x52, 0x3e, 0x0e, 0x0c, 0x86, 0x8e, 0xbf, 0xe1, 0x95, 0xc6, 0x72, 0x75,
  0xcf, 0x68, 0xe5, 0x31, 0x35, 0xa9, 0x41, 0x73, 0xbe, 0x04, 0x25, 0x2d, 0x41, 0xa2, 0x48, 0x94, 0x76, 0x35, 0x21, 0x25,
  0x4a, 0xb4, 0x5d, 0xf9, 0xfb, 0xdf, 0xfe, 0xbd, 0x42, 0xbb, 0xf6, 0x89, 0xdb, 0x6a, 0x77, 0xc5, 0x5b, 0x67, 0xf5, 0xb8,
  0xe2, 0x7c, 0xaf, 0xde, 0x77, 0x87, 0xbd, 0x41, 0x5f, 0x7c, 0xaa, 0xae, 0x8e, 0xa9, 0x20, 0xd0, 0x9f, 0x1f, 0xc2, 0xeb,
  0xc0, 0xaf, 0xb6, 0x6a, 0x50, 0xf6, 0x9f, 0xa1, 0xb0, 0xf6, 0x9d, 0x2b, 0xa8, 0x22, 0x2e, 0x16, 0x79, 0xfd, 0x7d, 0x45,
  0x1b, 0x94, 0xd0, 0x71, 0x51, 0xfe, 0xad, 0x72, 0xa4, 0x34, 0x71, 0x81, 0xe3, 0xff, 0xf2, 0x67, 0xff, 0xb6, 0xbb, 0x6b,
  0xc0, 0xdf, 0xb6, 0xf8, 0xfb, 0xf0, 0x18, 0x66, 0x0f, 0x52, 0x0f, 0x95, 0xe2, 0x6d, 0x23, 0x06, 0x29, 0xdf, 0xc8, 0xfb,
  0x6d, 0x91, 0xe7, 0xfc, 0xfd, 0x6f, 0xff, 0x5d, 0x8e, 0x84, 0x1c, 0x76, 0x69, 0x07, 0x8f, 0x2b, 0xef, 0xdc, 0xf6, 0xa8,
  0x85, 0xc1, 0x27, 0x7f, 0xaa, 0xe0, 0xd8, 0xe8, 0x42, 0xd1, 0x00, 0x0b, 0x08, 0xfc, 0xaf, 0x04, 0xab, 0xc6, 0xd3, 0x5f,
  0x2b, 0xf5, 0xdb, 0xab, 0x20, 0xf8, 0x04, 0xe2, 0x36, 0x90, 0x05, 0x92, 0xe5, 0xeb, 0xf4, 0x7b, 0xb5, 0xa5, 0x30, 0x89,
  0x4a, 0x9d, 0x64, 0x73, 0xf5, 0xed, 0x06, 0x98, 0x9e, 0xf6, 0x11, 0xc7, 0x80, 0x97, 0x8f, 0x8e, 0x2a, 0xbf, 0xbe, 0x7b,
  0x46, 0xf4, 0x44, 0x4d, 0x79, 0x09, 0x92, 0x5b, 0xed, 0x76, 0x39, 0xf9, 0x89, 0xce, 0x7b, 0xc3, 0xef, 0xcf, 0x9f, 0x5b,
  0x63, 0x53, 0x92, 0x7c, 0xed, 0x25, 0x17, 0xcd, 0xf9, 0x22, 0x02, 0x56, 0xbc, 0x3c, 0xee, 0xb7, 0x6a, 0xb5, 0xe6, 0xda,
  0xf3, 0x29, 0xae, 0xa0, 0xda, 0xae, 0x57, 0x5a, 0x15, 0x80, 0xe3, 0xa8, 0xf2, 0x58, 0x14, 0x5e, 0x7e, 0x07, 0x25, 0xb2,
  0x05, 0xf4, 0x5d, 0xb4, 0x44, 0x51, 0x55, 0x70, 0x95, 0xc9, 0x65, 0x13, 0x00, 0x1e, 0x26, 0x55, 0x68, 0xa0, 0x46, 0x52,
  0x2f, 0x0f, 0x43, 0x89, 0x0b, 0xde, 0xfb, 0xd6, 0x87, 0x7f, 0xea, 0xb7, 0x1e, 0x7b, 0xef, 0xdd, 0x0f, 0x5a, 0x23, 0x52,
  0x9a, 0xff, 0x79, 0x9d, 0xc4, 0x9a, 0xe4, 0x9b, 0x26, 0x69, 0xc5, 0xa6, 0xd6, 0x93, 0xd3, 0xdf, 0x33, 0xc7, 0x21, 0x1f,
  0xde, 0xae, 0x81, 0x2b, 0xee, 0x8e, 0x40, 0xd4, 0x11, 0xf3, 0xc5, 0x67, 0xdc, 0x20, 0xe2, 0xf1, 0xb2, 0x76, 0x56, 0x91,
  0x31, 0xc2, 0x30, 0xa6, 0xca, 0xee, 0xf4, 0xe1, 0x2d, 0x4a, 0xd7, 0xeb, 0x26, 0x31, 0x92, 0x9d, 0x8a, 0x36, 0xf9, 0xbd,
  0xd6, 0xfc, 0x4b, 0x14, 0xae, 0xaa, 0x15, 0x63, 0x72, 0xc2, 0x78, 0x9a, 0x19, 0x96, 0x21, 0xe5, 0x7f, 0xd3, 0xa1, 0xf1,
  0xb0, 0xf6, 0x8d, 0x6a, 0xba, 0x0d, 0x17, 0x3e, 0xdf, 0x17, 0x10, 0x03, 0xe5, 0x42, 0x69, 0xf1, 0x02, 0x36, 0xf7, 0x18,
  0xd8, 0x45, 0x15, 0x1f, 0x96, 0x93, 0xc6, 0xa0, 0xdd, 0x1a, 0x2f, 0x9f, 0x4c, 0x86, 0x5d, 0xf8, 0xe7, 0xf1, 0xa4, 0xd3,
  0x92, 0x2b, 0x84, 0x52, 0xd9, 0x64, 0x09, 0x83, 0x68, 0x81, 0x32, 0x31, 0x5a, 0x9e, 0xc2, 0x3f, 0xb8, 0xd8, 0x7f, 0xff,
  0x7f, 0xfe, 0x1b, 0xb0, 0xf6, 0x09, 0x21, 0x86, 0x37, 0x8d, 0x01, 0x6b, 0x58, 0xd5, 0x93, 0x45, 0x7f, 0x8a, 0xc4, 0x35,
  0x03, 0x95, 0xd1, 0xef, 0x0f, 0x6f, 0xb1, 0x91, 0xdd, 0xc3, 0x5b, 0x0d, 0x8d, 0x3c, 0x44, 0xa3, 0xdd, 0xe8, 0xe1, 0xad,
  0x40, 0x1a, 0xcf, 0x8a, 0x34, 0xbf, 0x8f, 0x2f, 0x1e, 0x4f, 0xf2, 0x70, 0x5a, 0xee, 0x8e, 0x60, 0xea, 0xd4, 0x9f, 0x36,
  0xf3, 0x1d, 0x70, 0x05, 0xfd, 0xd2, 0x04, 0xc0, 0xa7, 0x70, 0xb5, 0x0a, 0x36, 0x3f, 0xbe, 0x7b, 0xfd, 0x6a, 0x72, 0xa1,
  0xcb, 0x7b, 0x42, 0x82, 0xe3, 0x74, 0x07, 0xd5, 0xcb, 0x7a, 0x88, 0x31, 0x61, 0x6c, 0x51, 0x91, 0xdb, 0xbd, 0xfa, 0xbe,
  0xe5, 0x7e, 0xf8, 0xb3, 0xff, 0xb9, 0xfd, 0xbe, 0xd5, 0xe8, 0x7c, 0xa8, 0x8d, 0xe0, 0x9f, 0x1e, 0x3c, 0xab, 0x4d, 0xaf,
  0x36, 0x3b, 0xd2, 0x2c, 0x21, 0x12, 0x2c, 0x27, 0x84, 0xda, 0x12, 0x73, 0xa9, 0xd5, 0x47, 0x8f, 0x18, 0x20, 0x6e, 0xb7,
  0xdb, 0x1a, 0x2d, 0xb5, 0x41, 0x6c, 0xd0, 0xe8, 0xb7, 0xf9, 0x9e, 0xac, 0x3c, 0x71, 0x35, 0xde, 0xcc, 0xea, 0xb0, 0x18,
  0xb3, 0x40, 0x8e, 0x42, 0x00, 0x1f, 0x3f, 0x4e, 0xe0, 0x63, 0x73, 0x9a, 0x90, 0x4a, 0x1b, 0x7f, 0xfe, 0xfc, 0xfe, 0x43,
  0xfd, 0xe1, 0x66, 0x42, 0x73, 0xd5, 0x6f, 0xdf, 0xab, 0xd4, 0xea, 0xe2, 0xf2, 0x1f, 0x7f, 0xa2, 0xdb, 0x8e, 0x4e, 0x71,
  0x35, 0xe4, 0x17, 0xc4, 0x1a, 0x22, 0xe1, 0xd4, 0xd7, 0xa3, 0x47, 0x0f, 0x37, 0x4d, 0x14, 0x51, 0x40, 0x54, 0x89, 0xab,
  0x8a, 0xad, 0xb3, 0x94, 0x26, 0x98, 0xba, 0x9c, 0xe7, 0x18, 0x8a, 0xa6, 0xd0, 0xa4, 0x71, 0x11, 0x1e, 0x57, 0xaf, 0xeb,
  0x61, 0x0d, 0x71, 0x39, 0x73, 0x4b, 0xe0, 0x51, 0xfe, 0xde, 0xc0, 0x24, 0x5a, 0x4b, 0x17, 0x08, 0x7b, 0x10, 0xdf, 0xe9,
  0x69, 0xb5, 0xd8, 0xd1, 0xa9, 0x87, 0xe5, 0x3d, 0xbc, 0x95, 0xc3, 0xde, 0x69, 0x4b, 0x9f, 0x54, 0xaf, 0x9b, 0x9c, 0xde,
  0xa2, 0xb6, 0xcb, 0x39, 0x35, 0x71, 0xda, 0xd8, 0x2a, 0xa8, 0x1e, 0xe1, 0xae, 0x9e, 0x39, 0xee, 0x62, 0xbd, 0xcc, 0x70,
  0x9d, 0x66, 0xbb, 0xe7, 0x81, 0x14, 0x9d, 0xb6, 0xd1, 0x47, 0x63, 0xe9, 0x55, 0x9d, 0xb1, 0xc9, 0xf7, 0x0c, 0x9b, 0x54,
  0x27, 0x56, 0xd7, 0x4d, 0xf9, 0x88, 0xc4, 0x24, 0x17, 0xb1, 0x26, 0xc7, 0x21, 0xce, 0x2f, 0xdc, 0x75, 0x10, 0x74, 0xf8,
  0xa8, 0x60, 0x0c, 0x8a, 0x30, 0xd1, 0x10, 0xf0, 0x29, 0x3f, 0x02, 0x9b, 0x17, 0xda, 0xa1, 0x14, 0xe1, 0x93, 0x23, 0x23,
  0x60, 0xd7, 0xcc, 0x53, 0x7d, 0x64, 0x2e, 0x60, 0xea, 0x94, 0xd6, 0x47, 0xfc, 0xf0, 0xf6, 0xba, 0x29, 0x6c, 0x3a, 0x67,
  0x15, 0xe1, 0x6c, 0x26, 0x3a, 0x66, 0x9b, 0x8b, 0x36, 0x89, 0xaf, 0x3d, 0x3f, 0x42, 0x0b, 0x8d, 0x67, 0x47, 0xf4, 0x11,
  0x3c, 0x7a, 0x04, 0xaa, 0x0c, 0x30, 0xc4, 0x8f, 0x49, 0x04, 0x6c, 0x54, 0xd9, 0x1a, 0x2a, 0x44, 0x5a, 0x42, 0xd8, 0xb3,
  0xfa, 0x26, 0x02, 0x99, 0x91, 0xfe, 0x45, 0x2e, 0x3e, 0xba, 0xaf, 0xcd, 0xe2, 0x79, 0xba, 0xb1, 0xe4, 0xb5, 0x9c, 0x04,
  0x9e, 0xca, 0xe3, 0xaa, 0xd9, 0x3c, 0xfa, 0xb7, 0x84, 0xd9, 0x9d, 0x6e, 0xec, 0x43, 0xab, 0xd9, 0x08, 0x89, 0xb4, 0xee,
  0x1c, 0xd2, 0x88, 0x37, 0x88, 0x0f, 0xfa, 0x14, 0x30, 0x29, 0xf7, 0x0d, 0x9d, 0xc4, 0x37, 0x2f, 0x78, 0x13, 0x99, 0x80,
  0xb4, 0xcc, 0xbc, 0xdc, 0x52, 0x25, 0x67, 0xe1, 0x58, 0x83, 0x0e, 0xc3, 0x96, 0x56, 0xb2, 0x29, 0x70, 0xa6, 0xaf, 0xfa,
  0x32, 0x3e, 0x97, 0xb4, 0xe6, 0x13, 0x1a, 0xe0, 0x7e, 0x9e, 0x52, 0x96, 0x69, 0xfc, 0x5d, 0xe5, 0x22, 0xb5, 0xfa, 0x9c,
  0x8c, 0x1f, 0x3f, 0x44, 0x9b, 0x25, 0xc8, 0x24, 0x5e, 0xb5, 0x36, 0xc6, 0xaf, 0x4a, 0xd3, 0xf8, 0x04, 0x1a, 0x62, 0xc6,
  0xb2, 0xdc, 0xf4, 0x7c, 0xbf, 0xfa, 0xa9, 0x36, 0x9e, 0x37, 0x31, 0x27, 0xf0, 0x0a, 0x7e, 0x4b, 0x49, 0x9e, 0x9b, 0x7c,
  0xff, 0x09, 0xad, 0x47, 0xb5, 0x71, 0xd6, 0x14, 0xfe, 0xf8, 0xb1, 0x66, 0x06, 0x91, 0x76, 0x0c, 0x69, 0x99, 0xb9, 0x65,
  0xeb, 0xc9, 0x88, 0x6d, 0x27, 0xf5, 0x69, 0xe4, 0xdf, 0x8c, 0xe6, 0x3b, 0x12, 0x48, 0x71, 0x12, 0x6c, 0x81, 0xd2, 0xac,
  0x11, 0xf8, 0x32, 0x35, 0x39, 0x48, 0x5b, 0x40, 0x76, 0xe8, 0xd9, 0x91, 0xc3, 0x12, 0x05, 0xc0, 0x12, 0x3e, 0xd5, 0x6c,
  0xa3, 0xdb, 0x59, 0x81, 0xfa, 0x8c, 0x60, 0x5f, 0xd5, 0x01, 0x2a, 0x85, 0x91, 0x14, 0xe4, 0x95, 0x63, 0x98, 0xc7, 0x31,
  0x2f, 0x53, 0x45, 0x07, 0x7e, 0xae, 0x49, 0xf3, 0xca, 0x27, 0x10, 0x21, 0x10, 0x24, 0x0c, 0x0a, 0xad, 0xb7, 0x5b, 0xc1,
  0x0f, 0xb0, 0xd0, 0xe8, 0x72, 0x57, 0xaf, 0xd8, 0x2e, 0x8d, 0x65, 0x05, 0xd6, 0x47, 0x9b, 0x08, 0xf7, 0xdc, 0xd4, 0x6a,
  0x4d, 0x2e, 0xc7, 0xdc, 0x2a, 0x6c, 0xe1, 0x4f, 0x86, 0x99, 0x88, 0x20, 0x19, 0x48, 0x48, 0xd6, 0x99, 0x21, 0x89, 0xc2,
  0xe8, 0x98, 0x17, 0x43, 0xa8, 0xed, 0x8a, 0xc7, 0x2e, 0xae, 0x26, 0xda, 0x37, 0xfa, 0x8f, 0x2c, 0x22, 0x7c, 0x64, 0x7a,
  0x1e, 0xdb, 0x26, 0x22, 0xee, 0x2a, 0x2a, 0x9c, 0x4a, 0xa6, 0x89, 0x54, 0x54, 0xfa, 0x87, 0xcc, 0xce, 0x3c, 0xc4, 0x8f,
  0xb1, 0xac, 0x24, 0x2f, 0x64, 0xb1, 0xe8, 0xc2, 0x83, 0x15, 0x27, 0x6b, 0x34, 0x9b, 0xfd, 0xb1, 0xa0, 0x52, 0x0f, 0xc6,
  0xf8, 0xa4, 0x84, 0x6d, 0x6c, 0x42, 0x88, 0x0f, 0x7c, 0xd4, 0x7e, 0x22, 0xe6, 0x97, 0xa9, 0x7e, 0x76, 0xd6, 0x1a, 0xb3,
  0x75, 0x9c, 0x53, 0x0c, 0x08, 0x73, 0x37, 0x07, 0x18, 0x89, 0x07, 0x95, 0xed, 0x41, 0x7e, 0xd4, 0x0f, 0x17, 0x18, 0xef,
  0x30, 0xe6, 0xa7, 0xf2, 0x41, 0x6d, 0x04, 0x34, 0x34, 0x93, 0x7a, 0xd7, 0x54, 0x22, 0x04, 0x9b, 0x3a, 0xec, 0xab, 0x97,
  0x19, 0xda, 0x08, 0xff, 0xec, 0xea, 0x34, 0xca, 0x8a, 0x91, 0x55, 0x83, 0xc3, 0x7c, 0x04, 0xb1, 0x6c, 0x02, 0xbd, 0x53,
  0xe7, 0xa5, 0x29, 0xb5, 0x83, 0xec, 0x6c, 0xac, 0xce, 0x51, 0x5f, 0xa1, 0xa6, 0x28, 0x42, 0x8e, 0xa3, 0x95, 0xb6, 0xda,
  0x99, 0x2e, 0x27, 0xf8, 0x67, 0xcc, 0x22, 0x54, 0x66, 0x3d, 0xc4, 0x5b, 0x3d, 0x54, 0x3b, 0x5d, 0xfd, 0x6c, 0x0d, 0x06,
  0xb9, 0xad, 0xce, 0xd8, 0x8e, 0x28, 0x8a, 0x90, 0xfc, 0x47, 0xae, 0x85, 0xe8, 0x3a, 0x27, 0x3c, 0x6a, 0x33, 0x57, 0xfa,
  0x14, 0x8d, 0x21, 0x55, 0xe5, 0x50, 0xf6, 0x44, 0x6b, 0x89, 0x36, 0xbe, 0x5a, 0x99, 0xad, 0x8e, 0x8a, 0xd4, 0x64, 0x8d,
  0x74, 0x12, 0x65, 0x95, 0xee, 0x67, 0x6a, 0x09, 0xa0, 0xd4, 0x24, 0xdf, 0x9e, 0xf0, 0x77, 0xf9, 0x59, 0xa5, 0xa9, 0x40,
  0x65, 0x57, 0x33, 0x1f, 0x70, 0x29, 0xc4, 0x20, 0x11, 0x3c, 0x9e, 0x32, 0x35, 0xbe, 0x7c, 0x45, 0x60, 0x85, 0x71, 0xad,
  0x08, 0x22, 0x95, 0x25, 0xa9, 0x45, 0xe3, 0xeb, 0x53, 0x5a, 0x34, 0x8a, 0x13, 0x5a, 0x54, 0x72, 0x2b, 0xf1, 0x9b, 0x76,
  0xc1, 0xab, 0xb2, 0x0c, 0xad, 0x27, 0x52, 0x59, 0x93, 0x72, 0x59, 0xad, 0x7e, 0x3d, 0xa9, 0xa6, 0xf4, 0x4b, 0x5e, 0x38,
  0x82, 0x32, 0x3d, 0x7a, 0x58, 0x81, 0x53, 0x5e, 0x4e, 0x4e, 0x25, 0x05, 0x13, 0xba, 0xdf, 0x1a, 0x44, 0x81, 0xdb, 0x5d,
  0x9d, 0x05, 0xe0, 0xeb, 0xa6, 0xb8, 0xff, 0xe0, 0xe3, 0x3a, 0xd8, 0xe0, 0x15, 0xbe, 0x75, 0xb2, 0xe2, 0x8b, 0xf5, 0x6e,
  0x86, 0xf1, 0x4b, 0x80, 0xe5, 0x39, 0xd6, 0x26, 0xb9, 0xef, 0xd1, 0x23, 0xfa, 0x17, 0x54, 0x00, 0xf1, 0xeb, 0x09, 0x7a,
  0x84, 0xd9, 0x3f, 0x3b, 0x51, 0xfe, 0xa4, 0x35, 0xba, 0x93, 0x70, 0x75, 0xfe, 0x6d, 0x1b, 0xce, 0x3e, 0xe9, 0x53, 0xc9,
  0xac, 0xd0, 0xef, 0xe2, 0xf5, 0x08, 0x2a, 0x51, 0xbf, 0x67, 0xc2, 0x80, 0xf1, 0x9d, 0xba, 0x8e, 0x01, 0x96, 0x43, 0xcb,
  0x1c, 0x06, 0x92, 0x1d, 0x88, 0x3d, 0x0f, 0x6f, 0xa9, 0x43, 0xee, 0xe3, 0xaa, 0xa4, 0xf9, 0x6c, 0xab, 0xd0, 0xd8, 0xaf,
  0x07, 0x37, 0xc6, 0x97, 0xf4, 0x66, 0x9a, 0xa4, 0xf6, 0x50, 0xd2, 0x93, 0x60, 0xc3, 0x9c, 0x54, 0x1f, 0xbd, 0xe4, 0x2c,
  0xf7, 0x66, 0x54, 0xb1, 0x5f, 0xc8, 0x5b, 0xc9, 0xf6, 0xc3, 0xb1, 0x03, 0x99, 0x7e, 0xd2, 0xe6, 0xd8, 0xe4, 0x05, 0xd2,
  0x5b, 0x41, 0x73, 0xba, 0x1a, 0x2a, 0xb0, 0x03, 0x53, 0x2d, 0xd1, 0x2e, 0x2e, 0x41, 0x1c, 0x29, 0xc9, 0x08, 0xe4, 0x28,
  0x47, 0xa2, 0x6b, 0x85, 0x44, 0xd7, 0x0a, 0x89, 0xce, 0x9a, 0x18, 0x9b, 0x45, 0xc4, 0xf3, 0xf3, 0xe7, 0x56, 0x2d, 0x87,
  0xc1, 0xe9, 0x8d, 0xd0, 0x71, 0x3a, 0x0e, 0xe1, 0xb4, 0xcf, 0xa3, 0x31, 0x63, 0xd0, 0x9d, 0x47, 0x21, 0x94, 0x0e, 0x42,
  0xe8, 0xd8, 0x5b, 0x06, 0x32, 0x2a, 0x20, 0x87, 0xbe, 0x69, 0xc3, 0x1b, 0x1a, 0xd7, 0x47, 0xdc, 0xac, 0xb2, 0x13, 0x40,
  0xeb, 0xd2, 0xef, 0x69, 0x4f, 0x75, 0xf8, 0xb4, 0x09, 0x41, 0x2a, 0xd0, 0x3a, 0x7b, 0xf4, 0x88, 0x62, 0x1a, 0xa0, 0x33,
  0x8e, 0x6d, 0xb0, 0x36, 0x15, 0xd7, 0xce, 0xec, 0xef, 0x9b, 0xa0, 0x74, 0xcc, 0x82, 0x6a, 0xab, 0xce, 0x21, 0x11, 0x09,
  0xce, 0x6e, 0x72, 0x7a, 0xfd, 0xe8, 0x11, 0xea, 0x3d, 0xd1, 0xdc, 0xb9, 0x6e, 0xa6, 0xe1, 0x38, 0x68, 0x74, 0x05, 0xa2,
  0xb3, 0x08, 0x3c, 0x20, 0x86, 0xa3, 0xf7, 0x1f, 0xc6, 0xa4, 0xb3, 0x67, 0x6e, 0x14, 0xcf, 0xee, 0x01, 0xfb, 0xfd, 0xe2,
  0x02, 0xeb, 0xc9, 0xd6, 0x03, 0xb8, 0xc5, 0x3b, 0x17, 0x74, 0x0c, 0x31, 0xcf, 0xc7, 0x6e, 0x8d, 0x37, 0x44, 0xf6, 0x66,
  0x6f, 0xc3, 0x04, 0x22, 0x80, 0xd1, 0xe4, 0xbc, 0x2a, 0x67, 0xf2, 0x11, 0xb5, 0xf8, 0xd4, 0xcd, 0x23, 0x75, 0xd3, 0x49,
  0x6a, 0x49, 0xa3, 0xd5, 0x5c, 0x83, 0xac, 0xcc, 0xee, 0x24, 0x4d, 0x7f, 0xad, 0xa3, 0x50, 0x36, 0x51, 0x53, 0xa7, 0xa7,
  0x09, 0x9a, 0x7d, 0x51, 0xd8, 0xaf, 0x90, 0x86, 0x05, 0xaf, 0xce, 0xf8, 0x1f, 0x11, 0xbb, 0xa1, 0x93, 0x07, 0x89, 0xd5,
  0xbf, 0x6b, 0xf7, 0xf3, 0x16, 0x1e, 0xad, 0x41, 0xdd, 0x2d, 0x05, 0xae, 0xe1, 0x1c, 0x26, 0x9d, 0xcd, 0xfc, 0x9a, 0xde,
  0xba, 0x0e, 0x65, 0x7e, 0x20, 0x87, 0x64, 0x65, 0x27, 0x35, 0x45, 0xbd, 0x0b, 0x10, 0x1c, 0xc3, 0x23, 0x69, 0xe3, 0x13,
  0x13, 0x3b, 0x93, 0x80, 0xfe, 0x55, 0x5c, 0x30, 0x25, 0x3f, 0x90, 0xbe, 0x26, 0xb4, 0x4d, 0x71, 0x5d, 0xb0, 0xa8, 0x8a,
  0x33, 0xc4, 0x8f, 0xf2, 0x4e, 0xe0, 0xdf, 0x77, 0xa9, 0x2e, 0x37, 0xaa, 0xdc, 0xf9, 0x7e, 0xf5, 0x02, 0x16, 0xc3, 0x19,
  0xe1, 0x0a, 0x45, 0x4e, 0x40, 0x56, 0xb5, 0xcb, 0x53, 0x79, 0x53, 0x18, 0xa7, 0x50, 0x6c, 0xca, 0x93, 0x9c, 0xba, 0x3a,
  0x28, 0x26, 0x85, 0x86, 0x14, 0xf1, 0xf9, 0x86, 0xb6, 0x8f, 0x72, 0xf2, 0x48, 0x37, 0xa4, 0x3c, 0x61, 0xe4, 0xd5, 0xd3,
  0x58, 0x3d, 0xf6, 0x72, 0xaa, 0x95, 0xe0, 0xe4, 0x76, 0x50, 0x80, 0xf9, 0x97, 0xb4, 0x10, 0x13, 0x15, 0x72, 0x6b, 0xb6,
  0x96, 0x94, 0xd4, 0x73, 0x5f, 0x8d, 0xec, 0xf3, 0x67, 0xbb, 0x80, 0x8d, 0x10, 0xf9, 0xa8, 0x1c, 0xaf, 0x35, 0x4b, 0xaf,
  0xd6, 0xc6, 0xee, 0x73, 0xf7, 0x87, 0xb5, 0x49, 0x4e, 0x91, 0x8a, 0x96, 0xc1, 0x11, 0xe4, 0x1d, 0xd5, 0xd6, 0x59, 0xc5,
  0x4c, 0x3b, 0x59, 0x21, 0x51, 0x18, 0x60, 0xd4, 0x3e, 0xab, 0x88, 0xa4, 0x7b, 0x32, 0x5f, 0xb9, 0xfa, 0xe4, 0x9e, 0x55,
  0x7e, 0x12, 0x39, 0xfb, 0xd2, 0x6f, 0x95, 0x4c, 0x56, 0xc8, 0x8a, 0x90, 0xa6, 0xa5, 0x51, 0xc2, 0xaa, 0x26, 0xde, 0x1d,
  0x23, 0x0e, 0x9c, 0xb4, 0x89, 0x38, 0xc5, 0x5c, 0x40, 0x28, 0x2c, 0x16, 0xa4, 0xa2, 0xb9, 0x16, 0xa3, 0xc9, 0x99, 0x40,
  0xb5, 0x02, 0x34, 0xa9, 0x8d, 0x50, 0xd7, 0x31, 0xeb, 0xd6, 0xcd, 0x92, 0xf8, 0x68, 0x24, 0xdc, 0xa1, 0x37, 0x5a, 0x7a,
  0x9e, 0x43, 0xb4, 0x1b, 0xcb, 0xda, 0x6a, 0x76, 0x1e, 0xf4, 0xf8, 0x6f, 0x56, 0x95, 0x22, 0x25, 0x48, 0x42, 0x56, 0x80,
  0x67, 0x24, 0x59, 0x8e, 0x0e, 0x71, 0x53, 0x33, 0x4a, 0x53, 0x71, 0xd2, 0x71, 0xbc, 0xb1, 0x76, 0x01, 0x6f, 0xf6, 0xea,
  0x15, 0x41, 0x21, 0x48, 0x65, 0x4a, 0xab, 0xa9, 0xfc, 0x8b, 0x72, 0x1e, 0x7c, 0x28, 0x0e, 0x1b, 0x13, 0xaa, 0x12, 0x09,
  0x0f, 0x5f, 0xca, 0x96, 0xd1, 0x94, 0xb2, 0xae, 0xad, 0x53, 0x41, 0x81, 0x76, 0x73, 0xaa, 0x3c, 0x7d, 0xfb, 0xf6, 0x19,
  0x81, 0xf6, 0xab, 0x5a, 0x5f, 0xb5, 0xd6, 0x42, 0xc3, 0xcf, 0x51, 0xd1, 0x9d, 0xc5, 0x18, 0x9f, 0x1e, 0x88, 0x91, 0xd3,
  0x8d, 0x56, 0x93, 0xfb, 0xf7, 0xd3, 0x09, 0xe3, 0xd9, 0xa3, 0x8f, 0x2a, 0x96, 0x2f, 0x60, 0x92, 0x63, 0x1c, 0xa5, 0xd1,
  0x88, 0x61, 0xb4, 0x52, 0x28, 0xa6, 0x9d, 0x90, 0x02, 0x02, 0x12, 0xad, 0xce, 0x28, 0xa8, 0x6f, 0xa4, 0x81, 0x92, 0xd5,
  0x9f, 0x8f, 0x88, 0x67, 0x67, 0x67, 0x84, 0x9f, 0x67, 0x95, 0x5f, 0xbc, 0x6d, 0xcc, 0x77, 0x66, 0x69, 0x07, 0x89, 0x2a,
  0x1c, 0x18, 0x88, 0x6d, 0x94, 0x92, 0x87, 0xec, 0x11, 0x9f, 0x68, 0x55, 0x4a, 0x26, 0x32, 0x33, 0xcb, 0x52, 0x01, 0xb1,
  0xd7, 0xef, 0x0c, 0x0b, 0x63, 0xcb, 0x15, 0x6f, 0xa5, 0x4c, 0x5b, 0x23, 0x98, 0x9d, 0x3b, 0x6a, 0xed, 0x68, 0x96, 0x2f,
  0x8d, 0xf3, 0x5e, 0x46, 0xa0, 0xa4, 0x40, 0xfe, 0xfd, 0x27, 0xb2, 0x70, 0x27, 0x95, 0xb5, 0x53, 0xb8, 0xa3, 0xec, 0x73,
  0x05, 0x38, 0x44, 0x2b, 0x63, 0x67, 0x14, 0x94, 0x3b, 0x0c, 0xc3, 0xcb, 0x21, 0xc7, 0x91, 0xbe, 0x16, 0x14, 0xb5, 0x61,
  0xf0, 0x8f, 0x1c, 0x86, 0x5e, 0xce, 0x12, 0x44, 0xac, 0x3a, 0x2a, 0x91, 0x31, 0x49, 0x89, 0xe6, 0x5a, 0x03, 0xce, 0xa7,
  0x33, 0xca, 0x94, 0x65, 0xdc, 0xe4, 0xb5, 0x16, 0x7d, 0xfd, 0x22, 0x5b, 0x51, 0x88, 0x8f, 0xd0, 0x51, 0xa8, 0x6f, 0x96,
  0x92, 0x7b, 0x00, 0x17, 0x96, 0x13, 0xa3, 0xc8, 0x23, 0x95, 0xd2, 0x4e, 0x04, 0x2b, 0xf5, 0xe6, 0xe9, 0x6b, 0xe6, 0xa7,
  0x26, 0x96, 0x1b, 0xbd, 0x12, 0xc1, 0xce, 0x29, 0x7c, 0xf9, 0x71, 0xd3, 0x62, 0x82, 0x82, 0x47, 0x2a, 0x99, 0x3c, 0x08,
  0x2d, 0xba, 0xac, 0xe4, 0x5a, 0xb4, 0x6a, 0x77, 0xf6, 0x46, 0x95, 0xaa, 0x57, 0xc5, 0x41, 0x3e, 0x45, 0xac, 0xa6, 0xbb,
  0x9a, 0x28, 0x0d, 0x5e, 0x26, 0x15, 0x0f, 0xca, 0xa0, 0x78, 0xee, 0x57, 0x9d, 0x12, 0x48, 0x4d, 0x5f, 0xf2, 0x60, 0x29,
  0x25, 0xf7, 0xe1, 0x6c, 0xdf, 0x45, 0xfb, 0xd9, 0x84, 0xe4, 0xbe, 0x0d, 0xbd, 0x67, 0x91, 0x45, 0xe0, 0xdd, 0xc4, 0xba,
  0x92, 0x75, 0xd3, 0x16, 0x59, 0x88, 0x06, 0xa2, 0x11, 0x73, 0xe1, 0xe5, 0x4b, 0x73, 0xeb, 0x97, 0xa3, 0xc3, 0x9d, 0xf8,
  0x6e, 0x66, 0x2c, 0x06, 0xb1, 0x78, 0xbe, 0xef, 0xdc, 0xae, 0xc0, 0x32, 0x7d, 0xa3, 0x8f, 0x2a, 0xb9, 0xf2, 0xfa, 0x29,
  0x0f, 0x89, 0x8d, 0x63, 0x3e, 0xbb, 0x9d, 0x5b, 0x43, 0x93, 0x52, 0x64, 0x06, 0xa7, 0x40, 0x52, 0x8c, 0x41, 0x93, 0xfd,
  0xf8, 0x83, 0xf9, 0xdd, 0x38, 0x27, 0xb9, 0xb1, 0x65, 0xee, 0x88, 0x56, 0x36, 0x82, 0x95, 0x1d, 0xee, 0x61, 0x04, 0x2b,
  0xb7, 0xc4, 0x26, 0x8d, 0x52, 0x44, 0x48, 0xa7, 0x50, 0xd6, 0x44, 0x25, 0xb7, 0xd9, 0x63, 0x0d, 0x1a, 0xae, 0x64, 0xd3,
  0x12, 0x01, 0x66, 0xfc, 0xba, 0xe2, 0x0d, 0x2c, 0x72, 0x63, 0x28, 0x5c, 0xc9, 0x6b, 0x4b, 0xa9, 0x29, 0xd7, 0x70, 0xab,
  0x97, 0x1a, 0xeb, 0x33, 0x61, 0xe7, 0x99, 0x0d, 0x23, 0x5e, 0xa7, 0x2c, 0xd0, 0x52, 0x07, 0x45, 0x1c, 0xea, 0x0f, 0xb4,
  0x8c, 0xcc, 0xcc, 0x6a, 0xb7, 0x0f, 0xab, 0x16, 0x4b, 0x70, 0x4a, 0x34, 0x65, 0x13, 0x0f, 0x33, 0x33, 0xdf, 0x24, 0x4a,
  0x7d, 0x5a, 0x26, 0x55, 0x4b, 0xdf, 0xa4, 0x3d, 0x9e, 0x9d, 0xb9, 0xad, 0x61, 0xab, 0x36, 0xce, 0x74, 0xe2, 0xef, 0xa9,
  0x0b, 0xb0, 0x80, 0x9a, 0xed, 0x56, 0xb6, 0xa6, 0x74, 0x40, 0xa9, 0xea, 0x96, 0xba, 0xd2, 0x93, 0x04, 0x94, 0x35, 0x9f,
  0x65, 0x06, 0x90, 0xcd, 0x62, 0x90, 0x2e, 0xf4, 0x6d, 0xb0, 0x62, 0x59, 0xb4, 0xee, 0x19, 0x50, 0x9e, 0xe5, 0xf0, 0x60,
  0x74, 0xdf, 0xe2, 0x91, 0x95, 0x06, 0xe5, 0x9f, 0x59, 0x6c, 0xf6, 0x83, 0x95, 0x26, 0x49, 0x45, 0xab, 0xca, 0xc8, 0x32,
  0x27, 0xb6, 0x69, 0xc3, 0x76, 0xd4, 0x13, 0x51, 0x89, 0xd8, 0x57, 0x0c, 0x11, 0x54, 0x47, 0xe6, 0xd9, 0xcb, 0x9b, 0x1d,
  0xd9, 0xe7, 0xcf, 0xca, 0xbb, 0x2c, 0x7b, 0x27, 0x04, 0x1d, 0xa9, 0xe1, 0x95, 0x88, 0x6c, 0x99, 0x04, 0x33, 0x77, 0xc3,
  0xd5, 0x22, 0xd5, 0xae, 0xc8, 0x09, 0x65, 0xe2, 0x74, 0x39, 0x6a, 0xd6, 0x09, 0xc3, 0x26, 0x99, 0xb0, 0x99, 0x62, 0x3c,
  0xad, 0xd5, 0x61, 0x28, 0xa5, 0xc5, 0x35, 0xc4, 0xac, 0xd5, 0xc9, 0x1b, 0x59, 0x8a, 0x7d, 0xb8, 0xad, 0x78, 0x0c, 0x1c,
  0x23, 0x88, 0x60, 0xf6, 0xd5, 0x6f, 0xf9, 0x05, 0xde, 0xc1, 0xb6, 0xc3, 0x7a, 0x7b, 0xf7, 0x5a, 0xe9, 0x1e, 0x66, 0xda,
  0x57, 0x79, 0x81, 0x87, 0x63, 0x81, 0xa2, 0xce, 0xe9, 0x20, 0x63, 0xc2, 0x57, 0x25, 0x8b, 0x4b, 0xc3, 0xe8, 0xf4, 0xa4,
  0x48, 0xc9, 0x28, 0xee, 0x00, 0xe4, 0x00, 0x0d, 0xcf, 0xb1, 0xa6, 0x75, 0x6a, 0x56, 0xea, 0x4a, 0x0d, 0x41, 0xf0, 0xef,
  0x0c, 0xa1, 0xfa, 0x76, 0x37, 0x7e, 0xdf, 0x6c, 0x36, 0xcd, 0xb3, 0x30, 0xf5, 0xdc, 0xda, 0x7d, 0xd0, 0x1d, 0xd7, 0x5c,
  0xf5, 0xfd, 0xa7, 0x0f, 0x62, 0x67, 0xa2, 0x4f, 0x5d, 0x2c, 0x6a, 0xe8, 0xcb, 0x83, 0x34, 0x25, 0x4e, 0x27, 0xed, 0x10,
  0x4d, 0xba, 0x24, 0x75, 0xdb, 0x1a, 0xe4, 0x7c, 0x55, 0xf5, 0x83, 0x5d, 0x5f, 0x1f, 0xc6, 0x30, 0x96, 0x03, 0xf4, 0x70,
  0x4b, 0xf8, 0x40, 0x1e, 0x73, 0x8b, 0xb9, 0xc2, 0xc1, 0xb2, 0x83, 0x65, 0xb5, 0xd5, 0xce, 0x04, 0x09, 0xa2, 0x9e, 0xa3,
  0xaa, 0x23, 0xfa, 0x5b, 0xcf, 0x50, 0x4c, 0xa8, 0xe3, 0xd7, 0x6d, 0x94, 0x70, 0x84, 0x7f, 0x76, 0xf5, 0x94, 0x16, 0xe5,
  0x53, 0xdb, 0xc9, 0x5d, 0x21, 0x6d, 0x00, 0x9a, 0xf3, 0x4a, 0xda, 0x51, 0x50, 0x20, 0x79, 0x5e, 0x94, 0x14, 0xaf, 0x40,
  0x53, 0x11, 0x71, 0x1b, 0x7c, 0xa3, 0xbd, 0x20, 0xb3, 0xf5, 0xb2, 0xf9, 0x7e, 0xa3, 0xb9, 0x92, 0x52, 0x2f, 0x9a, 0xac,
  0x15, 0xf8, 0x6a, 0xdd, 0xb1, 0xf5, 0xec, 0x62, 0x2a, 0x8d, 0x58, 0x07, 0x2f, 0x5d, 0xb3, 0xf6, 0x73, 0x8f, 0x7b, 0xe4,
  0x93, 0x82, 0xb0, 0x0e, 0x0b, 0x52, 0xed, 0x41, 0x50, 0xc3, 0x78, 0x90, 0xfa, 0x5b, 0x8b, 0xf9, 0x58, 0xde, 0x95, 0x4c,
  0x38, 0xae, 0x0b, 0x42, 0xb4, 0x47, 0x08, 0x77, 0xdf, 0x81, 0x48, 0x57, 0xf5, 0x55, 0xbc, 0x88, 0xdf, 0xf4, 0xd6, 0xdc,
  0x50, 0xe5, 0xad, 0xc8, 0xcf, 0x55, 0x19, 0xf9, 0xdc, 0x8b, 0x48, 0xcc, 0x82, 0x58, 0xf5, 0x4c, 0xfe, 0xac, 0xd0, 0xd1,
  0x40, 0x3c, 0xf5, 0x9c, 0x37, 0x17, 0x8b, 0xc4, 0x1a, 0xdc, 0x0f, 0xf6, 0x81, 0x51, 0x7f, 0x02, 0xd0, 0xc0, 0x19, 0x7e,
  0xbe, 0x5a, 0x55, 0xfd, 0x7a, 0x45, 0xf4, 0x57, 0xa9, 0x3d, 0x7a, 0x94, 0xff, 0x68, 0xf6, 0x6b, 0xd1, 0x1f, 0xf8, 0x03,
  0x10, 0xd3, 0xec, 0x18, 0xf1, 0x30, 0x85, 0x9c, 0x8b, 0xf2, 0x25, 0xf3, 0x8c, 0x43, 0x0a, 0xd7, 0xcf, 0x3b, 0x93, 0x29,
  0x38, 0xbc, 0x41, 0xdc, 0xb1, 0xae, 0xda, 0xa9, 0xdd, 0xa9, 0x32, 0x7a, 0x02, 0xea, 0xf7, 0xcd, 0xca, 0x17, 0xc1, 0x26,
  0xc2, 0xb5, 0xc8, 0x68, 0x74, 0xb9, 0x25, 0x48, 0xdd, 0x9f, 0xf0, 0xe5, 0x65, 0xd6, 0x35, 0x9d, 0x2e, 0x4c, 0x95, 0x7e,
  0x86, 0x6b, 0x90, 0x79, 0xdc, 0x93, 0x76, 0xd3, 0xed, 0x0f, 0x9b, 0xdd, 0xa6, 0x5b, 0xa9, 0x8d, 0xd2, 0xf5, 0xa9, 0x0a,
  0x68, 0x50, 0xa1, 0xa7, 0xbe, 0x4f, 0x59, 0x89, 0x75, 0xaf, 0x47, 0x6d, 0x24, 0x7c, 0xdc, 0x80, 0x65, 0x29, 0x78, 0x35,
  0xf2, 0x86, 0xe9, 0xcc, 0x59, 0xb4, 0x30, 0xc6, 0x58, 0xd7, 0x70, 0x40, 0x3f, 0x19, 0x97, 0x5b, 0x7b, 0x71, 0x10, 0xe0,
  0xc7, 0xc0, 0x5b, 0x24, 0x17, 0x85, 0x6b, 0x4f, 0x86, 0xbb, 0x9b, 0x38, 0x09, 0x96, 0x1f, 0xb5, 0xb1, 0xd9, 0x10, 0x81,
  0xb1, 0xfd, 0xa3, 0x48, 0x44, 0xf6, 0x91, 0xd2, 0x9a, 0x65, 0xd1, 0x41, 0x9b, 0x20, 0x80, 0xcb, 0xd6, 0x36, 0x70, 0x68,
  0x3e, 0x01, 0x4d, 0xf5, 0x27, 0x5a, 0x05, 0xe0, 0xda, 0x80, 0x2f, 0xb6, 0x5e, 0x70, 0x59, 0x0a, 0x93, 0xbf, 0xc1, 0x22,
  0xf1, 0x49, 0x9d, 0xc9, 0xfd, 0x6c, 0x61, 0x2d, 0x59, 0x9a, 0x56, 0xca, 0xec, 0xb2, 0x9a, 0xae, 0xea, 0x59, 0x7a, 0x28,
  0x5c, 0xbe, 0xab, 0x19, 0xad, 0x19, 0x89, 0xe0, 0x32, 0xc8, 0xa1, 0xb5, 0x4a, 0x61, 0x82, 0x96, 0x44, 0x73, 0x78, 0x8f,
  0xe9, 0xc2, 0xa7, 0x63, 0xfc, 0x53, 0x4c, 0x81, 0xb7, 0x5d, 0x51, 0x62, 0xbe, 0x17, 0x32, 0x41, 0x17, 0xeb, 0x95, 0xe2,
  0xb0, 0x50, 0xcc, 0x69, 0xa5, 0xa6, 0x18, 0x6e, 0xf0, 0x29, 0x58, 0x27, 0x4d, 0xe7, 0x5f, 0xa3, 0x2d, 0x9e, 0xca, 0x77,
  0x82, 0xeb, 0xf5, 0x22, 0x9c, 0x85, 0x78, 0x49, 0x45, 0x40, 0x69, 0xdd, 0xf8, 0xd8, 0x1b, 0x05, 0x77, 0x9b, 0x57, 0x2f,
  0xc9, 0x7e, 0xe9, 0x50, 0x1f, 0x65, 0x56, 0x91, 0x09, 0xff, 0x90, 0xb9, 0x3c, 0xd5, 0x0a, 0x62, 0x57, 0x7c, 0x5e, 0x4f,
  0x1b, 0x4f, 0x26, 0x5d, 0x5c, 0x76, 0x3c, 0x7c, 0xf2, 0x8e, 0x12, 0x00, 0x06, 0x97, 0x98, 0xaf, 0x4d, 0x1d, 0xbf, 0x53,
  0x89, 0xae, 0xb5, 0xb1, 0x36, 0xf3, 0xb1, 0x88, 0x96, 0xac, 0x75, 0x7c, 0x4c, 0x9b, 0x51, 0x95, 0x30, 0x61, 0xb3, 0x04,
  0x11, 0x8c, 0x67, 0xb9, 0x58, 0x64, 0x46, 0x54, 0x17, 0x29, 0x1e, 0x70, 0xac, 0xbc, 0x95, 0x30, 0xe3, 0x02, 0xc0, 0x2e,
  0x04, 0x04, 0xab, 0x9b, 0x69, 0x4c, 0xe0, 0x39, 0x4d, 0x0c, 0x84, 0x03, 0x4d, 0x75, 0x7d, 0xa1, 0xfb, 0x8a, 0xe0, 0x0f,
  0xe1, 0x86, 0x3b, 0x73, 0xf8, 0x32, 0x47, 0xce, 0x82, 0x30, 0x45, 0x87, 0xa5, 0x4f, 0x12, 0x9c, 0x42, 0x78, 0x91, 0x78,
  0xb1, 0xcc, 0xb2, 0x69, 0x44, 0xfd, 0x89, 0xc5, 0x38, 0xa6, 0x59, 0x57, 0xea, 0xb7, 0x62, 0x7a, 0xa3, 0xca, 0x8b, 0x37,
  0x4f, 0xdf, 0xbe, 0xf8, 0xf8, 0xf6, 0xe9, 0x1f, 0x5f, 0x3c, 0xff, 0xf8, 0xf6, 0xc5, 0xbb, 0x77, 0x2f, 0x7f, 0xfa, 0xc3,
  0xdb, 0xca, 0x4e, 0x86, 0x1e, 0x65, 0x71, 0x89, 0x96, 0x1c, 0x56, 0x09, 0xb1, 0x91, 0xe8, 0x00, 0x46, 0xc5, 0x20, 0xbc,
  0xd3, 0x94, 0x12, 0xbc, 0xc8, 0x2b, 0x99, 0x53, 0x89, 0xc2, 0x5e, 0xc4, 0xb4, 0x60, 0xfc, 0x29, 0xc3, 0xcd, 0xce, 0xa0,
  0x94, 0xa7, 0xe6, 0xc8, 0x8b, 0x4a, 0xd2, 0x56, 0xa2, 0xa3, 0x50, 0xae, 0xb5, 0x8f, 0x98, 0x5c, 0xad, 0x48, 0x9d, 0x4e,
  0xe9, 0x82, 0x60, 0xa6, 0x5a, 0x15, 0xf5, 0xed, 0xbe, 0xa4, 0x19, 0xba, 0x19, 0x3e, 0xdf, 0x36, 0xee, 0xd5, 0x6c, 0x7a,
  0x39, 0xd3, 0x0e, 0x6f, 0x2f, 0x90, 0xba, 0x07, 0x55, 0x8f, 0x82, 0x0c, 0x67, 0x32, 0x05, 0x56, 0xea, 0xe9, 0x1e, 0x27,
  0xe3, 0xfd, 0x8a, 0x79, 0x6f, 0x26, 0x42, 0x25, 0x53, 0x4a, 0xea, 0x7a, 0x23, 0x29, 0x95, 0xea, 0xa3, 0xb0, 0x45, 0x40,
  0xa5, 0x74, 0xe4, 0x1f, 0x9b, 0x9c, 0x0e, 0x46, 0x94, 0xed, 0x40, 0xbf, 0xef, 0x2f, 0xcd, 0x31, 0x2a, 0x32, 0x82, 0x80,
  0x20, 0x76, 0x4c, 0x54, 0x66, 0xac, 0x25, 0x1b, 0x4c, 0x77, 0x88, 0x0a, 0xf0, 0xb3, 0x99, 0x2d, 0x73, 0x29, 0xfd, 0xca,
  0xcc, 0x96, 0x65, 0x68, 0xc3, 0x87, 0x85, 0x8b, 0x30, 0x45, 0x72, 0x17, 0x19, 0xe3, 0xa7, 0x21, 0xa9, 0xa9, 0x73, 0x69,
  0x76, 0xcf, 0x3c, 0x46, 0xd4, 0xb3, 0x6e, 0x0e, 0x0b, 0xae, 0xdd, 0xd9, 0xe6, 0x99, 0xc3, 0xa5, 0xc3, 0x15, 0x96, 0x7c,
  0xf7, 0x86, 0xb1, 0x53, 0x5f, 0xc4, 0x9c, 0x5d, 0x73, 0x9c, 0x4d, 0x28, 0x69, 0xe4, 0x7b, 0x34, 0x2f, 0x1d, 0xa0, 0x7e,
  0xb2, 0x68, 0x91, 0xd7, 0x34, 0xc6, 0x66, 0x4e, 0x49, 0x65, 0x25, 0xd5, 0x2c, 0xa0, 0xf9, 0x11, 0xdb, 0x7d, 0x25, 0x96,
  0x72, 0x87, 0x99, 0x1e, 0x73, 0xcb, 0x9b, 0x27, 0x50, 0x7a, 0x5a, 0x78, 0xcd, 0x8f, 0x27, 0x7a, 0x96, 0x39, 0xe5, 0x3f,
  0x42, 0x9f, 0xb2, 0xef, 0xd4, 0xab, 0x91, 0x4f, 0x57, 0x6f, 0xf7, 0x6b, 0xe4, 0x2e, 0x26, 0x60, 0x5f, 0x45, 0xee, 0x8a,
  0x00, 0x41, 0x27, 0xf6, 0xbb, 0xeb, 0xf4, 0x41, 0x97, 0x6d, 0x11, 0xdb, 0xf0, 0x4b, 0x6c, 0xfb, 0xb6, 0xf9, 0x64, 0xac,
  0xfb, 0x25, 0x00, 0xb9, 0x33, 0xae, 0x5b, 0xc0, 0x72, 0x38, 0xb6, 0xdb, 0x06, 0x62, 0xe0, 0xfb, 0xf7, 0x25, 0x77, 0x31,
  0x14, 0x1b, 0xf6, 0xd3, 0x5b, 0x2c, 0x28, 0xc0, 0x13, 0x1d, 0xee, 0xf3, 0xb9, 0xd5, 0xd1, 0x67, 0x1b, 0x80, 0x1d, 0x7d,
  0xad, 0x25, 0xbf, 0x81, 0xed, 0xdc, 0x40, 0x5d, 0x23, 0x47, 0x41, 0x1c, 0xfa, 0x78, 0x5a, 0xf6, 0x15, 0x05, 0x6f, 0xc9,
  0xa3, 0xa9, 0x78, 0x76, 0x4f, 0x5c, 0x93, 0xd5, 0xa2, 0xc3, 0x7c, 0x62, 0xfd, 0x2f, 0x80, 0x59, 0xcc, 0x12, 0x4a, 0x7a,
  0xe9, 0x88, 0xa2, 0xc2, 0x7b, 0x1f, 0x85, 0xe8, 0xd0, 0x92, 0xdf, 0x41, 0xe8, 0xf6, 0x83, 0x5f, 0xf0, 0xdd, 0xd3, 0xa4,
  0xda, 0xc2, 0x34, 0x12, 0xd8, 0xd6, 0xe3, 0x09, 0x15, 0x7b, 0x32, 0x69, 0x5d, 0x0f, 0xe6, 0x00, 0x7d, 0xed, 0x69, 0x7e,
  0xd6, 0x4e, 0x1f, 0xe7, 0xf0, 0x9f, 0xb3, 0xce, 0xa8, 0xbb, 0x13, 0xfa, 0x2b, 0xd7, 0x2e, 0x34, 0x6c, 0xaa, 0xbd, 0xc8,
  0xc7, 0x1f, 0x26, 0xb7, 0x38, 0x27, 0x3c, 0x2a, 0x8f, 0xff, 0x4a, 0x53, 0xdf, 0x8e, 0x6c, 0x7d, 0xe6, 0x64, 0xb9, 0x7c,
  0x13, 0xdf, 0xd6, 0x4e, 0x3b, 0xed, 0xcf, 0x9f, 0x8f, 0xdf, 0xff, 0x79, 0xf3, 0xe7, 0xd5, 0x9f, 0x5b, 0x1f, 0xc4, 0x69,
  0x3c, 0xbd, 0x80, 0x0c, 0xf1, 0xaf, 0x18, 0xd7, 0xa1, 0x2d, 0xb7, 0x64, 0x6e, 0x73, 0x3c, 0x0c, 0x84, 0x82, 0x9f, 0x80,
  0x0f, 0xbf, 0xbe, 0xfb, 0xa1, 0x31, 0x74, 0xa6, 0x78, 0x02, 0x99, 0x38, 0x5e, 0xb4, 0x4d, 0x28, 0x83, 0x98, 0x33, 0xdd,
  0x04, 0xde, 0xa7, 0x38, 0x67, 0xb2, 0x83, 0x71, 0xc1, 0x58, 0xe5, 0x95, 0x62, 0xca, 0x7c, 0x29, 0xfa, 0x96, 0xef, 0x27,
  0x96, 0x32, 0x76, 0x74, 0x17, 0x87, 0x40, 0x2a, 0xd9, 0x3b, 0xc4, 0xa4, 0x4f, 0x5b, 0xc9, 0x79, 0x74, 0x5d, 0xcc, 0x5c,
  0xe5, 0xa5, 0x6f, 0xb2, 0x20, 0x91, 0xed, 0x64, 0x52, 0xa9, 0xec, 0x3b, 0xe5, 0x60, 0x39, 0xd2, 0x00, 0x4f, 0x3f, 0x25,
  0xeb, 0xea, 0x34, 0x59, 0x29, 0x42, 0xb9, 0xc0, 0xf3, 0x83, 0xab, 0x33, 0x5d, 0x32, 0xc1, 0x35, 0xa1, 0x22, 0xf0, 0x27,
  0xb3, 0xed, 0xf1, 0x8d, 0x2e, 0xc3, 0x54, 0x50, 0x10, 0xbd, 0xd8, 0x44, 0xab, 0x30, 0x16, 0x9b, 0x7e, 0x97, 0xce, 0x1e,
  0xcf, 0xf2, 0xb0, 0x4c, 0xbc, 0x4a, 0xd6, 0x94, 0xc7, 0xb0, 0x92, 0x39, 0xd7, 0x93, 0x4a, 0xbf, 0x98, 0xb4, 0x30, 0x56,
  0x6d, 0x79, 0x82, 0xbc, 0xcb, 0xfb, 0x95, 0x2b, 0x74, 0x3e, 0x27, 0x4d, 0xea, 0x31, 0xfb, 0x54, 0x27, 0x2f, 0xc6, 0x5e,
  0x10, 0xc8, 0x5d, 0x68, 0x9d, 0x11, 0xef, 0xc4, 0xec, 0x94, 0x00, 0x22, 0x3b, 0x3b, 0xe8, 0x94, 0x04, 0x66, 0x01, 0xa0,
  0x01, 0xbf, 0x03, 0xe0, 0xf6, 0x9b, 0xf4, 0xff, 0xc9, 0xeb, 0xa4, 0xe8, 0xc4, 0xb8, 0xfd, 0x3c, 0x14, 0xc3, 0x30, 0xcd,
  0x1b, 0x5c, 0x0a, 0x49, 0xed, 0x4c, 0x94, 0xe6, 0xe7, 0x64, 0x1d, 0x49, 0xd8, 0x14, 0x29, 0x9d, 0xa1, 0x15, 0xa8, 0x27,
  0x77, 0x81, 0xe9, 0xa1, 0xb0, 0xcc, 0x9d, 0xa2, 0x52, 0xd7, 0x84, 0x7d, 0x3d, 0x18, 0x7f, 0xe1, 0x44, 0x95, 0x77, 0x00,
  0x1e, 0xf6, 0x7e, 0x10, 0xf0, 0x44, 0xd3, 0x19, 0xa0, 0x39, 0xbf, 0x88, 0x8b, 0xa5, 0xb4, 0x9b, 0xa4, 0x72, 0xb7, 0x48,
  0x71, 0xda, 0x7b, 0x0b, 0x7c, 0x7b, 0xff, 0x11, 0xf0, 0xcd, 0x5e, 0xca, 0xb5, 0x27, 0x70, 0x40, 0x8b, 0x44, 0x2a, 0x0d,
  0x1a, 0x48, 0x5b, 0xb4, 0x05, 0x0c, 0xe4, 0xe2, 0x99, 0x0a, 0xe4, 0x86, 0x32, 0xc5, 0x59, 0xe5, 0xd4, 0xb9, 0x35, 0x1b,
  0x34, 0x84, 0x02, 0x3d, 0xf6, 0x47, 0x3b, 0x6a, 0xa4, 0xbf, 0xb6, 0x7b, 0xea, 0xb5, 0x06, 0x59, 0xb0, 0x11, 0x56, 0x5e,
  0xba, 0x84, 0x8d, 0xf0, 0xf1, 0xe5, 0x6a, 0x1e, 0xe9, 0xc7, 0x87, 0xec, 0x75, 0x05, 0xdb, 0x2f, 0xa8, 0xfd, 0x65, 0xe2,
  0x00, 0x2c, 0xa2, 0x96, 0x93, 0x22, 0x20, 0xfb, 0x56, 0xe6, 0x52, 0x7b, 0x69, 0x35, 0xbe, 0x95, 0x92, 0x12, 0x6b, 0xca,
  0xde, 0xc2, 0xdb, 0x2c, 0x53, 0x73, 0xbf, 0xfe, 0x72, 0xc4, 0x91, 0xef, 0xa8, 0x42, 0x56, 0x6f, 0x99, 0x59, 0x8f, 0x7a,
  0xbb, 0x3a, 0xa6, 0x87, 0xa9, 0x66, 0x5a, 0xc1, 0x24, 0x7a, 0xa3, 0x41, 0x9d, 0x4f, 0xd5, 0x01, 0xa4, 0x6b, 0x35, 0x7a,
  0xb5, 0xb8, 0xf9, 0x38, 0xbb, 0x00, 0xfc, 0x1d, 0x35, 0x5c, 0xca, 0x28, 0xb1, 0xc9, 0xf4, 0xc3, 0xef, 0x62, 0xe4, 0x5c,
  0x7e, 0x3c, 0xea, 0xb4, 0x5a, 0x75, 0x4a, 0xf3, 0xf7, 0x71, 0xe9, 0xc5, 0x9f, 0x46, 0xad, 0xba, 0x99, 0xd9, 0x6f, 0x84,
  0xeb, 0x5f, 0xd7, 0xf2, 0xf3, 0xf1, 0x8b, 0x34, 0xdd, 0x9e, 0x68, 0x54, 0x4f, 0x9d, 0xc7, 0x45, 0xd2, 0x14, 0x78, 0xa2,
  0x88, 0x99, 0xcb, 0x4e, 0x14, 0x12, 0xe9, 0xe6, 0xa0, 0x5f, 0x6a, 0xd2, 0xf3, 0xff, 0x02, 0x42, 0x40, 0x16, 0x30, 0xe9,
  0x17, 0xad, 0x77, 0x51, 0x54, 0xcc, 0xbe, 0xd3, 0xd2, 0x05, 0xb1, 0x15, 0x0e, 0x7f, 0x11, 0xfe, 0x35, 0x30, 0x97, 0x43,
  0x48, 0x59, 0xf7, 0x1c, 0x99, 0x1d, 0x88, 0x96, 0x2c, 0x9e, 0xd8, 0xd7, 0xae, 0xbe, 0xa1, 0xab, 0xb5, 0x27, 0x98, 0xd9,
  0x4b, 0x16, 0xdd, 0x69, 0x02, 0xdc, 0xa7, 0xe0, 0x06, 0x45, 0x37, 0xfd, 0x34, 0xae, 0x2c, 0x56, 0xab, 0xc1, 0xd6, 0xa5,
  0xde, 0x1e, 0x3d, 0x32, 0x2d, 0xb5, 0xf4, 0xb2, 0x0e, 0x85, 0x71, 0xd3, 0x62, 0xf3, 0xef, 0xe1, 0xf7, 0x87, 0x09, 0xbd,
  0xa6, 0x9f, 0xe3, 0x7b, 0x0e, 0x7f, 0x68, 0x32, 0x3e, 0x4c, 0x0a, 0xf0, 0xe1, 0x23, 0x1d, 0xe9, 0x17, 0xa4, 0xf3, 0x7a,
  0x62, 0x9e, 0x97, 0xa0, 0xe6, 0xce, 0x44, 0x0b, 0x35, 0x3e, 0xab, 0x23, 0x9e, 0xde, 0x87, 0x1f, 0x46, 0x94, 0x0e, 0x21,
  0x8b, 0x99, 0xf7, 0xef, 0x5f, 0x9f, 0xc9, 0x33, 0xd3, 0x8c, 0x5a, 0xb9, 0x13, 0x1f, 0x50, 0x00, 0x3f, 0xd4, 0xf0, 0xd0,
  0x00, 0xfe, 0xa0, 0x33, 0x4b, 0xfc, 0xf3, 0xc9, 0xa4, 0xdd, 0x39, 0xe3, 0x9f, 0x29, 0x4a, 0xda, 0x1a, 0x10, 0x69, 0x01,
  0xb0, 0x1e, 0xff, 0x14, 0x8d, 0xf0, 0xc3, 0x93, 0x49, 0xef, 0xe4, 0x4c, 0x3e, 0x00, 0x4a, 0x03, 0x8d, 0xbf, 0xe7, 0xa0,
  0xb9, 0x31, 0xd7, 0x94, 0x00, 0x92, 0x81, 0xcc, 0xb5, 0xcf, 0x9f, 0x6d, 0xaf, 0x9f, 0xb8, 0xf6, 0xf7, 0xa7, 0xc3, 0x3e,
  0xe6, 0x99, 0xb3, 0x7d, 0x9a, 0xc0, 0xb6, 0x18, 0x97, 0xf5, 0x9b, 0x47, 0xc1, 0xb4, 0xf3, 0xfc, 0xb7, 0x27, 0xad, 0x92,
  0x8f, 0xa7, 0xbd, 0x93, 0x5a, 0xe1, 0x47, 0x18, 0x88, 0x5c, 0x29, 0x2e, 0x33, 0xbe, 0xa7, 0x7b, 0xa9, 0x74, 0x8c, 0x55,
  0x31, 0xdf, 0x92, 0xe8, 0xdc, 0x35, 0x06, 0x38, 0x17, 0x3c, 0x4e, 0x87, 0x80, 0x8a, 0xba, 0x7b, 0xe6, 0xad, 0xd3, 0x53,
  0x48, 0xb3, 0x89, 0x7d, 0x28, 0xcd, 0x39, 0xbf, 0xf9, 0x38, 0xf3, 0xd6, 0xde, 0x34, 0x5c, 0x80, 0xf8, 0x84, 0x83, 0xb8,
  0xdd, 0x29, 0xf4, 0xd3, 0x68, 0x8f, 0x8c, 0x3f, 0x69, 0xa6, 0xef, 0x30, 0xcd, 0x8d, 0x24, 0x8c, 0xf7, 0xef, 0xcf, 0x04,
  0x0e, 0x9b, 0x64, 0x0e, 0xdf, 0xeb, 0x2f, 0x98, 0xc0, 0xd1, 0x6b, 0xfa, 0x25, 0x08, 0xde, 0xd2, 0xbb, 0x56, 0x44, 0x2f,
  0x7f, 0x96, 0xa9, 0x99, 0x2b, 0x84, 0x27, 0x98, 0xf2, 0x6f, 0x4f, 0x27, 0xae, 0xf5, 0xfd, 0x93, 0x09, 0x21, 0xd3, 0x99,
  0xe5, 0xd3, 0xa8, 0xd3, 0x6f, 0x19, 0xe4, 0x8d, 0x67, 0x92, 0x3e, 0xeb, 0x20, 0x06, 0x32, 0x61, 0x92, 0x21, 0x00, 0x5c,
  0xac, 0x56, 0x14, 0x1f, 0x34, 0xe8, 0x7c, 0xfe, 0x4c, 0x2f, 0x18, 0x28, 0xe2, 0x41, 0x87, 0x84, 0x78, 0x45, 0x23, 0x92,
  0x65, 0xb5, 0x6e, 0xd3, 0x5e, 0x31, 0x7b, 0x6e, 0x96, 0x73, 0xdd, 0x73, 0xd2, 0x43, 0x75, 0xd0, 0x21, 0x33, 0x7d, 0xe3,
  0xac, 0x52, 0x36, 0x3b, 0xac, 0x3c, 0xa5, 0xf4, 0xbb, 0xe5, 0x42, 0x6a, 0xba, 0x4f, 0x49, 0x35, 0xf6, 0x26, 0xba, 0xfa,
  0x88, 0x87, 0x81, 0x80, 0xe0, 0xed, 0x32, 0x97, 0x70, 0xa9, 0x32, 0x5a, 0x01, 0xfc, 0x25, 0x13, 0xc9, 0x58, 0xae, 0xde,
  0xb2, 0x54, 0xc9, 0xde, 0xbd, 0xa5, 0xcf, 0x2d, 0x7b, 0xfd, 0x96, 0xcc, 0x5b, 0xd2, 0x70, 0x8f, 0x4e, 0xb5, 0x23, 0x1e,
  0x42, 0xb0, 0x51, 0xa9, 0x6b, 0x44, 0xdb, 0x94, 0xa5, 0x4b, 0x26, 0x49, 0x3d, 0x7b, 0x5f, 0x79, 0xb1, 0x3a, 0x5f, 0x84,
  0x31, 0xe6, 0x1c, 0x7c, 0x8b, 0xb9, 0xde, 0xe9, 0xd7, 0x0f, 0x98, 0x54, 0x1b, 0x7f, 0xfc, 0x21, 0x00, 0x3e, 0x84, 0xf1,
  0x17, 0x2f, 0x13, 0x0c, 0xbc, 0xc2, 0x5f, 0x6f, 0xb6, 0xa0, 0x01, 0xc3, 0x2f, 0xce, 0x1e, 0xca, 0xd9, 0x0c, 0x39, 0x39,
  0x4b, 0x36, 0x81, 0x4e, 0x48, 0x33, 0x2f, 0xcc, 0x1c, 0x34, 0xca, 0xd6, 0x70, 0x19, 0x50, 0x37, 0x41, 0xbc, 0xcb, 0xde,
  0xc0, 0x25, 0x8b, 0xb4, 0xb8, 0xc8, 0x2a, 0xd2, 0x33, 0xf2, 0x64, 0xb2, 0x8b, 0x68, 0x5d, 0x8c, 0x53, 0x1c, 0x78, 0x8a,
  0x38, 0x66, 0xc1, 0x81, 0x52, 0xee, 0x64, 0x20, 0x02, 0x35, 0xd3, 0x20, 0x5c, 0x15, 0x77, 0x8b, 0x64, 0x97, 0x9d, 0xfa,
  0x40, 0xc9, 0x9b, 0xe7, 0x4e, 0x8f, 0x98, 0x4a, 0xf5, 0xb1, 0xbb, 0xb3, 0xdd, 0x15, 0x97, 0xaf, 0x62, 0xbb, 0x30, 0xae,
  0x35, 0xa0, 0x0b, 0xe3, 0x0e, 0xc2, 0x87, 0x03, 0xf2, 0xaa, 0x78, 0xda, 0xa0, 0x8e, 0xec, 0xc3, 0xf9, 0x79, 0xa5, 0x0f,
  0xc6, 0x76, 0xf5, 0x87, 0xbd, 0xb5, 0xc3, 0xc6, 0x78, 0x70, 0x72, 0x15, 0x63, 0x1d, 0x0d, 0xf3, 0xab, 0xe7, 0xe7, 0xf7,
  0xfa, 0xbe, 0x63, 0x44, 0x48, 0x3c, 0x26, 0x16, 0xfa, 0x4f, 0xb9, 0xb3, 0x27, 0x05, 0xf2, 0x56, 0x3e, 0x57, 0xf5, 0x7b,
  0xd1, 0xc3, 0x87, 0xcf, 0x9f, 0xf7, 0x30, 0x0c, 0x3f, 0x88, 0x51, 0x48, 0x47, 0x1c, 0xc4, 0x2e, 0x9a, 0x7a, 0x14, 0x9c,
  0x5e, 0x33, 0x67, 0x00, 0x26, 0xb6, 0xad, 0x57, 0x91, 0x49, 0xa0, 0xf0, 0xdd, 0x98, 0x3e, 0xa4, 0x14, 0x74, 0xd2, 0x82,
  0xf6, 0x53, 0x91, 0x8e, 0x88, 0x15, 0x0a, 0x75, 0x59, 0xd2, 0x26, 0xf9, 0x1c, 0x23, 0x55, 0x7a, 0x32, 0x4a, 0xa3, 0x3d,
  0x95, 0xc7, 0x54, 0x1b, 0x69, 0x84, 0x34, 0x3b, 0x91, 0x3b, 0xc4, 0x24, 0xd9, 0x8f, 0xaa, 0xee, 0x93, 0x27, 0x5c, 0x70,
  0x1a, 0x26, 0xda, 0xe1, 0xef, 0xda, 0x6d, 0x66, 0x68, 0x9f, 0x27, 0x7a, 0x49, 0x1a, 0xf8, 0x7b, 0xd5, 0xc3, 0x87, 0x89,
  0xfa, 0x69, 0x12, 0x24, 0x6a, 0x6e, 0xc4, 0xc3, 0x9c, 0x4c, 0x5c, 0x60, 0x2d, 0x0c, 0x3e, 0x53, 0xe3, 0x98, 0x68, 0x7c,
  0xe3, 0xd1, 0x23, 0x63, 0x8f, 0x5b, 0x00, 0x4a, 0x12, 0x98, 0xa5, 0x95, 0x9a, 0xf6, 0xee, 0x20, 0x31, 0x15, 0x37, 0xe6,
  0xc4, 0xe8, 0x0d, 0xb7, 0x6e, 0xe5, 0x71, 0x28, 0x00, 0x56, 0x5f, 0xe3, 0x4d, 0x61, 0x93, 0x7c, 0x62, 0xaf, 0xaa, 0xc8,
  0xec, 0x55, 0x7b, 0x78, 0xdc, 0x0c, 0xae, 0x83, 0x19, 0x65, 0x88, 0xad, 0xe5, 0x44, 0x58, 0xa3, 0xe9, 0x9f, 0x57, 0xd4,
  0xb0, 0x0c, 0x8f, 0x24, 0xc9, 0x94, 0xda, 0x97, 0x07, 0xdb, 0xe8, 0xe1, 0xbd, 0x0b, 0xcd, 0x83, 0xa2, 0x24, 0x24, 0x4e,
  0x4b, 0x81, 0x36, 0x15, 0x60, 0x49, 0x94, 0x26, 0xac, 0x73, 0xd8, 0x49, 0x8e, 0xe7, 0x9e, 0x65, 0x90, 0xe3, 0x47, 0xfa,
  0xf6, 0x0c, 0x3f, 0xa5, 0x47, 0xe7, 0x1a, 0x2e, 0x23, 0xa2, 0xa1, 0x9e, 0x4d, 0x52, 0x66, 0x9d, 0xae, 0x09, 0xa5, 0x4c,
  0xb6, 0x2d, 0x09, 0x43, 0x94, 0xee, 0x16, 0xce, 0xe2, 0x23, 0xd5, 0xc1, 0x7e, 0xe3, 0x34, 0x7e, 0x33, 0x93, 0x7a, 0xc5,
  0x28, 0xca, 0xc1, 0x9f, 0x5a, 0x61, 0x29, 0x04, 0xdb, 0x0a, 0xbf, 0xe5, 0x6f, 0xaa, 0xb0, 0x86, 0x1d, 0xc6, 0x6c, 0x6a,
  0xda, 0x2b, 0xd9, 0x1e, 0x8d, 0xf6, 0x9f, 0x50, 0x1c, 0x7a, 0x2c, 0xc6, 0x83, 0x49, 0x03, 0xc5, 0x57, 0x09, 0x5e, 0x8b,
  0x1e, 0x38, 0xc9, 0x8a, 0x2e, 0x1a, 0xce, 0xc2, 0xcb, 0xa7, 0xf4, 0xce, 0x4a, 0x08, 0x8a, 0x5a, 0x14, 0xbb, 0x4d, 0xfb,
  0x32, 0xc9, 0xb7, 0xa8, 0xac, 0xb6, 0xb0, 0xc3, 0xdc, 0xca, 0x38, 0xd7, 0x96, 0x90, 0xd0, 0x33, 0x50, 0x4a, 0xeb, 0x33,
  0x5c, 0x15, 0xa4, 0x76, 0xa8, 0xd9, 0xa5, 0x94, 0xe8, 0x5e, 0x36, 0xec, 0xde, 0x42, 0xef, 0x6f, 0x09, 0xb8, 0xc5, 0xa9,
  0xfa, 0x91, 0x6e, 0x08, 0xdb, 0x8f, 0x85, 0xd6, 0xe6, 0xa8, 0xf8, 0x87, 0x89, 0x85, 0xf8, 0xcb, 0x98, 0xa6, 0x4c, 0x27,
  0x14, 0x8b, 0x5a, 0x14, 0xca, 0x6f, 0x1c, 0xd4, 0xe3, 0x3a, 0x22, 0xe5, 0x36, 0x36, 0x78, 0xaf, 0xe0, 0x5c, 0x74, 0xb6,
  0xe0, 0x01, 0x6c, 0x87, 0x0d, 0x0a, 0x93, 0x52, 0x08, 0xd4, 0x0f, 0x67, 0x0d, 0xa9, 0x3c, 0x93, 0x2f, 0xa3, 0x6c, 0x3b,
  0xdc, 0xe7, 0xf8, 0xa1, 0x05, 0x26, 0x96, 0x62, 0xf7, 0x9c, 0x92, 0x9c, 0xbf, 0x0f, 0xb2, 0xf2, 0xb3, 0x88, 0x1f, 0xcd,
  0xa6, 0x87, 0xce, 0x34, 0xfa, 0xf9, 0xb3, 0x0c, 0x95, 0xcf, 0x89, 0x60, 0xc5, 0x03, 0x4e, 0x2b, 0x8d, 0xf7, 0x8e, 0x48,
  0x93, 0xe6, 0x1c, 0x12, 0x61, 0x0e, 0x1e, 0x10, 0xfc, 0xda, 0xc3, 0x2e, 0xf4, 0x21, 0x9b, 0xc4, 0xaf, 0x78, 0xc0, 0x05,
  0xd4, 0xae, 0xb8, 0xc2, 0x3d, 0xe7, 0x7d, 0x8e, 0xd6, 0xd5, 0x2d, 0x24, 0xad, 0x6e, 0xa1, 0x5c, 0xa5, 0x07, 0x51, 0x4b,
  0xe6, 0x6b, 0x27, 0xc5, 0xc6, 0x0a, 0x59, 0x88, 0x51, 0xf1, 0x1c, 0xde, 0xe7, 0xe8, 0x4d, 0xbd, 0x80, 0x82, 0x7c, 0xe9,
  0x88, 0x4b, 0x88, 0xa3, 0xa0, 0xdb, 0x5c, 0xf9, 0xd1, 0xa3, 0x92, 0xdb, 0x40, 0xd2, 0xb3, 0xc1, 0x25, 0x84, 0xc2, 0xe2,
  0x3e, 0x2e, 0xa7, 0x02, 0xb1, 0x24, 0x6e, 0xf7, 0xf5, 0xf4, 0xde, 0x45, 0x17, 0x96, 0x3c, 0x69, 0x3d, 0x7a, 0x74, 0xbf,
  0xd0, 0x9c, 0xc1, 0xe2, 0x86, 0x24, 0x84, 0xfb, 0x89, 0x0a, 0x27, 0x46, 0xb1, 0xcb, 0x9f, 0xc5, 0x82, 0x6e, 0x1a, 0xc5,
  0x72, 0xff, 0xbe, 0x5d, 0x4b, 0xaf, 0xfb, 0x48, 0x77, 0x27, 0x25, 0x52, 0x6f, 0x5d, 0x48, 0xb5, 0x45, 0x02, 0x33, 0x35,
  0x20, 0x44, 0x63, 0x9b, 0x24, 0x9c, 0xa5, 0x49, 0xf2, 0x6c, 0x75, 0x26, 0x3f, 0xc9, 0xcf, 0xf2, 0xca, 0x2f, 0xe5, 0xae,
  0xfc, 0x9f, 0xff, 0xc3, 0x51, 0x99, 0x84, 0x64, 0x3a, 0x92, 0xdd, 0xef, 0x96, 0x16, 0x9f, 0xf2, 0x2c, 0xd1, 0x52, 0x73,
  0x53, 0x1c, 0xf9, 0xf4, 0x34, 0xbd, 0x69, 0x98, 0xba, 0x92, 0x77, 0x45, 0x2d, 0xc3, 0x84, 0x13, 0x41, 0x51, 0x60, 0x92,
  0x48, 0x95, 0xe0, 0x2d, 0x43, 0xbc, 0xff, 0xfd, 0x37, 0xbc, 0xe8, 0x28, 0x76, 0x30, 0x6f, 0x78, 0xb0, 0xb9, 0xd4, 0xe2,
  0x20, 0x6f, 0xa2, 0xad, 0xb3, 0x08, 0x30, 0x10, 0x6a, 0x2b, 0x14, 0x20, 0x8e, 0x0f, 0xc0, 0x26, 0x05, 0xb6, 0x3a, 0xde,
  0x39, 0xa6, 0x3f, 0xd5, 0x7d, 0x38, 0xf2, 0x4e, 0x04, 0x74, 0x23, 0xe4, 0xe7, 0x9b, 0x8d, 0x96, 0x42, 0x87, 0x1d, 0x5f,
  0x5e, 0xc7, 0xb3, 0x17, 0x57, 0x49, 0x7a, 0xe9, 0x15, 0xcc, 0xc6, 0x68, 0xc7, 0x74, 0xa7, 0x1a, 0xdd, 0xae, 0x84, 0x67,
  0xff, 0xd7, 0x1e, 0x0c, 0x22, 0x71, 0x16, 0xde, 0x0d, 0xfa, 0x9f, 0xfd, 0x20, 0x01, 0xb5, 0x3e, 0x5c, 0xa1, 0x4b, 0xfa,
  0x22, 0x9c, 0xa9, 0xfb, 0x2b, 0x63, 0xcc, 0x15, 0x10, 0x78, 0x9b, 0x66, 0xc5, 0x02, 0xd7, 0xd7, 0x5e, 0x0c, 0xb5, 0xde,
  0x44, 0x57, 0x5a, 0xa8, 0x6b, 0x1a, 0xcf, 0x56, 0xc0, 0x6b, 0xf2, 0x05, 0x33, 0x46, 0x99, 0x3f, 0x6c, 0xa2, 0xed, 0x5a,
  0x2b, 0x98, 0x51, 0x36, 0xc6, 0x06, 0xa9, 0xb6, 0x16, 0x66, 0xe9, 0x5d, 0x15, 0x24, 0x52, 0x6d, 0x2d, 0xa8, 0xcb, 0xb8,
  0x26, 0xbd, 0xb6, 0x16, 0x27, 0xc1, 0x6f, 0x9c, 0x27, 0x44, 0xf6, 0x41, 0xa4, 0x42, 0xd5, 0x81, 0xea, 0x98, 0x01, 0x05,
  0xb4, 0x26, 0x19, 0xda, 0x97, 0x6c, 0x7c, 0x8f, 0xf2, 0xa5, 0xef, 0x28, 0x9a, 0xc9, 0x2b, 0x44, 0xe0, 0xec, 0x66, 0x7a,
  0x1b, 0x24, 0x9c, 0x6e, 0x8c, 0xa6, 0x84, 0x37, 0x6c, 0x89, 0xcb, 0x7b, 0xc6, 0xe9, 0xa5, 0x95, 0x7c, 0xe0, 0x28, 0x4c,
  0xf0, 0x90, 0xfb, 0x22, 0xba, 0x02, 0x94, 0xd9, 0x20, 0x1e, 0xa7, 0x68, 0x87, 0xae, 0xc5, 0xc5, 0xc8, 0x71, 0x1d, 0x16,
  0x76, 0x71, 0x8b, 0x3c, 0xbc, 0x4d, 0x01, 0xa5, 0x9b, 0x0b, 0x8f, 0x51, 0x3e, 0xde, 0x91, 0x64, 0x5f, 0x54, 0x04, 0x68,
  0x32, 0x16, 0xc2, 0x5c, 0xcf, 0x95, 0xb8, 0xb2, 0x6b, 0xfe, 0x3e, 0xb6, 0x8a, 0xfe, 0x50, 0x63, 0x92, 0xcf, 0x0d, 0x5e,
  0xd2, 0x2b, 0x41, 0xe4, 0xf8, 0xd8, 0xf9, 0x25, 0x5a, 0x2c, 0xc8, 0x21, 0x8a, 0x01, 0x19, 0x2b, 0xca, 0x91, 0x45, 0xb7,
  0xd3, 0xe0, 0x5d, 0x68, 0x5b, 0x21, 0x12, 0xa2, 0x87, 0x48, 0x0f, 0xf1, 0xf5, 0x1c, 0x54, 0x97, 0x42, 0xba, 0x06, 0x1a,
  0x2d, 0x1f, 0xbe, 0x82, 0x53, 0x93, 0xe9, 0xbc, 0x4e, 0xdb, 0x2c, 0x24, 0xfe, 0x7e, 0xca, 0x67, 0x80, 0x31, 0x38, 0x7b,
  0x65, 0x39, 0x3c, 0xd1, 0xc0, 0x84, 0xb1, 0x99, 0x0a, 0x05, 0x77, 0xc7, 0x1d, 0x8b, 0xda, 0x2e, 0x61, 0x26, 0x9b, 0x2f,
  0xc4, 0x9f, 0xb3, 0x02, 0x1d, 0x5c, 0x54, 0xd4, 0xb4, 0xf5, 0x51, 0xfe, 0x15, 0xfa, 0x46, 0x41, 0x0f, 0x44, 0x88, 0x3b,
  0x7b, 0x24, 0x2a, 0x6d, 0xaa, 0xa6, 0x02, 0x3e, 0x36, 0x5f, 0x2b, 0x29, 0xa1, 0x4a, 0xcf, 0xac, 0x79, 0x97, 0xa8, 0xdb,
  0x78, 0xdc, 0x54, 0x28, 0x2f, 0x54, 0x81, 0x9d, 0x3b, 0xa8, 0x92, 0x19, 0x6f, 0x85, 0x7b, 0xa3, 0x36, 0x2e, 0x51, 0xaf,
  0x61, 0x88, 0x5c, 0x58, 0x8c, 0x6c, 0x67, 0xcc, 0xcb, 0xa2, 0x03, 0x67, 0x81, 0xac, 0x93, 0x97, 0xda, 0xb8, 0x5c, 0xe4,
  0xd2, 0xe0, 0x61, 0xa8, 0x9c, 0x7a, 0x97, 0x79, 0x1d, 0xd8, 0xb2, 0x15, 0xcc, 0x56, 0x32, 0x3b, 0xa1, 0x4c, 0x45, 0x3e,
  0xb4, 0xad, 0xef, 0xb0, 0x2d, 0xca, 0xc5, 0x3f, 0x2e, 0x53, 0xa2, 0xb3, 0xc0, 0x30, 0xdb, 0x80, 0xea, 0x06, 0x92, 0x14,
  0x0b, 0x75, 0x3a, 0xa2, 0xe4, 0x75, 0xde, 0x71, 0x89, 0x86, 0x6b, 0xa9, 0x76, 0x06, 0x3a, 0xef, 0xa8, 0xd2, 0xaa, 0x8c,
  0xf7, 0x29, 0xb6, 0xd9, 0xd1, 0x5b, 0x5c, 0x63, 0x30, 0x7e, 0xd0, 0x7e, 0x0b, 0xaf, 0xa3, 0x13, 0x1b, 0x5f, 0xc4, 0x2f,
  0x08, 0xb7, 0xab, 0x29, 0x04, 0x69, 0x29, 0xfb, 0xd2, 0x1b, 0x4d, 0x15, 0xbb, 0xd7, 0x62, 0x8e, 0x72, 0xbc, 0xf4, 0x0d,
  0x35, 0x97, 0xa1, 0xea, 0xd2, 0x97, 0xe6, 0x14, 0xcb, 0xb4, 0x44, 0xaf, 0x2c, 0xa7, 0x98, 0x33, 0x54, 0x07, 0x84, 0x21,
  0xbc, 0xe2, 0x43, 0x1d, 0x0c, 0x4c, 0x07, 0x65, 0x4d, 0x1c, 0x95, 0x86, 0x4b, 0x88, 0xf6, 0xf9, 0xe8, 0x71, 0xae, 0xd1,
  0x34, 0x9f, 0xc6, 0xc1, 0xaa, 0x36, 0x9d, 0x7d, 0xf5, 0x92, 0x22, 0x9f, 0x37, 0xd2, 0x60, 0x76, 0x04, 0x9b, 0x76, 0x51,
  0x56, 0x04, 0x74, 0x17, 0xf1, 0x47, 0x75, 0x3e, 0x5a, 0x7f, 0xdb, 0x8c, 0xa3, 0x65, 0x80, 0xda, 0x61, 0xde, 0x27, 0xca,
  0x7e, 0xdf, 0xda, 0xe7, 0xcf, 0xc2, 0x17, 0xdc, 0x92, 0xbf, 0x4e, 0xdb, 0x1d, 0x50, 0x47, 0x2c, 0xe5, 0x95, 0xcb, 0x54,
  0x39, 0x7e, 0x5b, 0xe9, 0x6f, 0x74, 0x88, 0x9a, 0x37, 0x4b, 0xf1, 0x31, 0x5f, 0x4f, 0x1c, 0xef, 0x4d, 0xc4, 0xf5, 0x82,
  0x7c, 0x1f, 0x2e, 0xd3, 0x1d, 0x72, 0x56, 0x18, 0x91, 0x8b, 0x5f, 0xa1, 0x20, 0x0a, 0x3b, 0xe4, 0x3c, 0xf5, 0x6a, 0xa5,
  0x7a, 0x97, 0xb2, 0x7a, 0x89, 0x8c, 0x6d, 0xde, 0xb5, 0xa8, 0x66, 0x53, 0x1a, 0xf2, 0x7c, 0x76, 0xac, 0x60, 0x6d, 0x90,
  0xae, 0x47, 0x8f, 0xd8, 0xda, 0xc8, 0x40, 0xae, 0xd2, 0xed, 0x2e, 0x48, 0xbe, 0xe9, 0x4e, 0x93, 0xc7, 0xf2, 0x42, 0x03,
  0x7c, 0x0d, 0x30, 0x13, 0xd4, 0x99, 0x9e, 0x4e, 0xab, 0x21, 0x5d, 0x5d, 0xa0, 0x5f, 0xfe, 0xa1, 0x86, 0xc4, 0xa4, 0x6c,
  0x84, 0xe0, 0xb4, 0x2d, 0x83, 0x3e, 0x8e, 0xd4, 0x83, 0x6e, 0x79, 0x8b, 0x0e, 0x74, 0xcb, 0xeb, 0xd3, 0xb4, 0x27, 0x73,
  0xbd, 0x7e, 0x97, 0xeb, 0x35, 0xc3, 0x53, 0x54, 0x74, 0x1f, 0xbc, 0x14, 0x06, 0xf8, 0x6c, 0x84, 0x29, 0x07, 0x65, 0x06,
  0x2c, 0x65, 0x1f, 0x0d, 0xb4, 0x59, 0x79, 0xa7, 0x66, 0x20, 0x6d, 0x9e, 0xd4, 0x01, 0x38, 0x4d, 0xc8, 0xed, 0x35, 0xce,
  0x15, 0xc3, 0xc7, 0xea, 0xe9, 0x2f, 0xfa, 0x84, 0x68, 0x5c, 0xf4, 0x2d, 0x8f, 0xd6, 0xe9, 0xdd, 0x94, 0x5c, 0x90, 0xae,
  0x7e, 0xe5, 0xc2, 0x2a, 0x18, 0x96, 0xe0, 0xd5, 0x42, 0x40, 0xf5, 0x4e, 0x9a, 0xac, 0x56, 0xdb, 0x42, 0x77, 0x6d, 0xaa,
  0x75, 0xa9, 0xd5, 0xac, 0x20, 0x17, 0x81, 0x3d, 0x3b, 0xe1, 0x5e, 0x9d, 0x9a, 0xef, 0xb6, 0x63, 0x22, 0xc6, 0x37, 0xdc,
  0x09, 0x45, 0xd7, 0x66, 0x70, 0xb4, 0x13, 0x2a, 0xa9, 0xe6, 0xee, 0x4d, 0x03, 0x2e, 0x42, 0x7d, 0x4d, 0x7e, 0x92, 0x31,
  0x5a, 0x48, 0x8e, 0x62, 0x3f, 0xb5, 0x9e, 0xcd, 0x1f, 0x68, 0xc9, 0x71, 0xbf, 0x3f, 0x9f, 0x99, 0x91, 0xdd, 0x8e, 0x13,
  0x4f, 0x6a, 0x45, 0xf8, 0xc5, 0x01, 0xf9, 0xed, 0x4a, 0xc9, 0x7b, 0x2e, 0x1f, 0x1a, 0xac, 0x04, 0x42, 0x17, 0xc4, 0x81,
  0xa2, 0x98, 0x49, 0x76, 0xb3, 0x6a, 0x51, 0x79, 0x66, 0x4a, 0x7e, 0xbc, 0xe3, 0x3c, 0xd8, 0xc4, 0xa3, 0xdb, 0x8a, 0x60,
  0x85, 0x8d, 0x77, 0x20, 0xac, 0xc3, 0xbe, 0xa2, 0x3c, 0x77, 0x33, 0xda, 0xa3, 0xc7, 0x78, 0x29, 0x61, 0x65, 0xc7, 0xe9,
  0xfb, 0xff, 0xcf, 0xb7, 0x3f, 0xff, 0xd4, 0xe4, 0x64, 0xa1, 0xe1, 0xfc, 0xa6, 0x2a, 0xcd, 0x07, 0x75, 0x0a, 0x8a, 0xa2,
  0x15, 0xdb, 0xd5, 0x58, 0xda, 0xd3, 0xee, 0xca, 0xfc, 0xaa, 0xf4, 0x73, 0xd4, 0x42, 0xcd, 0x6a, 0x03, 0x91, 0x72, 0xca,
  0xb8, 0xc4, 0xc6, 0x42, 0x09, 0x27, 0x70, 0x3c, 0xf9, 0xe0, 0x50, 0x71, 0x89, 0xab, 0x76, 0xed, 0x75, 0x26, 0xc9, 0x1f,
  0x50, 0x29, 0xba, 0x0b, 0xca, 0x4c, 0xf4, 0xc7, 0x59, 0xfe, 0x48, 0x88, 0x39, 0x34, 0x0a, 0xb4, 0xfc, 0x76, 0xdd, 0xc2,
  0x93, 0xef, 0xff, 0x39, 0x10, 0xd3, 0x92, 0x8c, 0x2f, 0xdd, 0xbc, 0xf9, 0x14, 0x7d, 0xf7, 0xf4, 0x30, 0xc8, 0x1c, 0x65,
  0x50, 0x19, 0x09, 0x4b, 0x32, 0x97, 0x62, 0x49, 0x71, 0x2e, 0x5f, 0x4b, 0xa0, 0xac, 0x51, 0xe2, 0x75, 0xed, 0xd1, 0xa3,
  0x35, 0x05, 0x8a, 0xad, 0x9f, 0x98, 0xd7, 0x34, 0x89, 0x3c, 0xb9, 0xeb, 0x51, 0x2b, 0x9f, 0x79, 0x3d, 0x1b, 0xe5, 0x79,
  0x6b, 0xcb, 0x03, 0x3e, 0xb6, 0xa4, 0x56, 0xb6, 0xec, 0x3b, 0x3b, 0x30, 0x50, 0xa6, 0xba, 0x4b, 0xae, 0xbe, 0x5c, 0x76,
  0xb8, 0x71, 0x71, 0x16, 0x72, 0xb9, 0x6f, 0x26, 0xf6, 0xad, 0x54, 0xbf, 0x96, 0x9b, 0x26, 0x2e, 0xcb, 0x4a, 0x2e, 0xcb,
  0xbc, 0x5f, 0x7f, 0xa0, 0x8c, 0xce, 0x53, 0xe0, 0xc8, 0xa8, 0x27, 0x5c, 0x37, 0xe9, 0x17, 0x9e, 0xea, 0xbe, 0x46, 0xaa,
  0x88, 0x07, 0xe0, 0xc7, 0xe5, 0xd9, 0x85, 0xa1, 0x83, 0x4b, 0xce, 0x2e, 0xac, 0x36, 0xaf, 0xca, 0xc5, 0x7b, 0x56, 0x98,
  0x90, 0x16, 0xd7, 0x55, 0x9c, 0x85, 0x30, 0x96, 0x23, 0x23, 0x90, 0xd3, 0x68, 0xce, 0x2a, 0xcf, 0xf8, 0xca, 0x48, 0x90,
  0xa7, 0xb9, 0xb8, 0xb8, 0xd6, 0x1c, 0x13, 0x7f, 0xcb, 0x13, 0xc3, 0xf4, 0xbe, 0x92, 0x69, 0xf1, 0x39, 0x1e, 0x72, 0x5b,
  0xe8, 0xa7, 0xcd, 0xa9, 0xc1, 0x4c, 0x29, 0xbc, 0xf0, 0x2e, 0x97, 0x14, 0x9c, 0xb3, 0x08, 0xe7, 0x13, 0xad, 0x6b, 0xf5,
  0x44, 0x82, 0x80, 0x5c, 0x55, 0x01, 0xb7, 0x82, 0x14, 0x02, 0x99, 0x46, 0x0a, 0x6c, 0xb5, 0x65, 0xfd, 0xaa, 0xed, 0x6a,
  0xd6, 0xd9, 0x9f, 0x01, 0x79, 0x6c, 0xe4, 0x75, 0x2a, 0x8b, 0xf7, 0x2e, 0xc3, 0x60, 0x33, 0xc6, 0x3c, 0x17, 0x4e, 0x6e,
  0xe8, 0xfe, 0xf2, 0xf2, 0x00, 0xbd, 0x88, 0x35, 0x4f, 0xdf, 0xef, 0x5a, 0xcc, 0x37, 0xe6, 0xa8, 0x97, 0x29, 0x98, 0xd2,
  0xc4, 0x82, 0xea, 0x1e, 0x2c, 0x86, 0x87, 0xa7, 0xda, 0x2b, 0xb9, 0x8f, 0x40, 0x0f, 0x24, 0x0f, 0xd5, 0x39, 0xcb, 0xa6,
  0x76, 0xec, 0x5a, 0xbf, 0x90, 0xc0, 0x59, 0x84, 0xa0, 0x2c, 0xae, 0x62, 0x52, 0x22, 0x84, 0xee, 0x18, 0xcb, 0x73, 0xf8,
  0x69, 0x8e, 0x17, 0x03, 0x07, 0x9b, 0xce, 0xcb, 0x04, 0x98, 0xc2, 0x25, 0xc8, 0xb5, 0x78, 0x55, 0x2d, 0x9a, 0xbc, 0xd1,
  0x18, 0xc6, 0x80, 0x97, 0xc7, 0x0a, 0x52, 0x63, 0x1f, 0x65, 0x85, 0xc5, 0x13, 0xeb, 0x32, 0xa2, 0xf6, 0x90, 0xa1, 0x94,
  0x74, 0xfe, 0x03, 0x7c, 0x96, 0x47, 0xe4, 0x7d, 0xbe, 0xae, 0x9a, 0x6b, 0xc2, 0x8a, 0xd5, 0x85, 0xf9, 0x5c, 0x07, 0x82,
  0x3c, 0x3d, 0xc7, 0xdd, 0x8b, 0x3c, 0x00, 0xc4, 0x3b, 0x65, 0x7a, 0x3a, 0xba, 0x1d, 0x4c, 0x62, 0x0a, 0xdf, 0x24, 0x99,
  0x22, 0x0a, 0x3d, 0x7f, 0xfe, 0x5c, 0x55, 0xf7, 0x3d, 0x64, 0x0f, 0xbe, 0x50, 0x82, 0x53, 0x68, 0x12, 0x76, 0xbb, 0xaf,
  0x65, 0x60, 0x7e, 0x45, 0x63, 0xe2, 0xdc, 0x18, 0xd4, 0x46, 0xfd, 0x58, 0x9c, 0xc8, 0xf8, 0xfc, 0x4c, 0x1d, 0x94, 0xfa,
  0x8c, 0x50, 0xc0, 0x7f, 0x95, 0xfc, 0x2b, 0xa4, 0x74, 0xaa, 0x51, 0x93, 0x3a, 0xb1, 0xec, 0x5b, 0x3b, 0x91, 0x99, 0xcd,
  0xa1, 0x21, 0x60, 0xc5, 0xe7, 0x52, 0xb2, 0x19, 0xf1, 0x85, 0x59, 0x22, 0x1f, 0xd5, 0x5a, 0x57, 0x14, 0x4e, 0x14, 0x29,
  0x25, 0x5e, 0xe3, 0xbb, 0xa6, 0xb6, 0xbd, 0x2d, 0xdb, 0x53, 0x26, 0xd3, 0xc3, 0x54, 0x1e, 0xf6, 0x2b, 0xdd, 0xee, 0x4f,
  0xf8, 0x2e, 0xcf, 0x9a, 0xa6, 0x75, 0x4a, 0x82, 0xbf, 0xcb, 0x8c, 0xe9, 0x20, 0x1e, 0x7f, 0xe0, 0xa8, 0x04, 0xbd, 0xb9,
  0xeb, 0xb0, 0xa8, 0xda, 0xae, 0x56, 0x78, 0x3a, 0x43, 0x0b, 0x75, 0x08, 0x36, 0xe7, 0x22, 0x83, 0xa7, 0xca, 0x2b, 0xc1,
  0xd9, 0x4f, 0x72, 0x29, 0x4d, 0xec, 0x37, 0x07, 0xe0, 0xe0, 0xf6, 0x14, 0xc5, 0xf4, 0xd8, 0xb7, 0xe5, 0xd7, 0x0f, 0xf8,
  0x05, 0x1f, 0xc6, 0xf6, 0x2b, 0x05, 0x32, 0xf1, 0xf5, 0x7e, 0xfe, 0x2a, 0x02, 0xbf, 0xe4, 0x16, 0x82, 0xd1, 0xfb, 0x0f,
  0xbb, 0xdc, 0xb9, 0x81, 0xf7, 0x59, 0x12, 0x4b, 0xb3, 0xa0, 0x2d, 0xc0, 0x3f, 0xc5, 0xb1, 0x24, 0xf1, 0x20, 0xf8, 0x38,
  0x3f, 0x65, 0xb0, 0xa8, 0x6e, 0x5b, 0x43, 0x7a, 0x99, 0xa4, 0x09, 0xc2, 0xec, 0x77, 0x31, 0x55, 0xf2, 0x29, 0xcc, 0xea,
  0xf6, 0xe3, 0xcb, 0x75, 0xdb, 0xc1, 0x7f, 0xe3, 0xa5, 0x96, 0x63, 0xc1, 0x26, 0x00, 0xd5, 0x95, 0x72, 0x19, 0xcb, 0x53,
  0xc7, 0x96, 0x0c, 0xa8, 0xc6, 0x4b, 0x99, 0x17, 0x36, 0xff, 0x56, 0xb5, 0x51, 0x94, 0x93, 0xcd, 0xc8, 0x15, 0x58, 0xf9,
  0x50, 0xb3, 0x20, 0x18, 0x9a, 0xfc, 0x1f, 0x3d, 0xb2, 0x6e, 0x0a, 0xf1, 0xa9, 0x2a, 0x6c, 0xfb, 0xfa, 0x02, 0xa0, 0xa9,
  0xe6, 0xdb, 0x65, 0x71, 0xaf, 0xd5, 0x64, 0x6a, 0x38, 0x0c, 0xea, 0xf3, 0xf9, 0x08, 0x88, 0x95, 0xba, 0xe5, 0x13, 0x77,
  0xda, 0x6e, 0x44, 0xca, 0x27, 0x56, 0x28, 0xdc, 0xf7, 0xb6, 0xb4, 0x83, 0x07, 0x67, 0xd0, 0x2a, 0x6c, 0xb5, 0xf0, 0xe8,
  0x7b, 0xee, 0xe4, 0xf4, 0x37, 0x90, 0x9e, 0xf3, 0x72, 0xba, 0xca, 0x56, 0x6f, 0x35, 0xfb, 0xa6, 0x9b, 0x5b, 0xc3, 0x43,
  0x36, 0x2a, 0x9b, 0xc9, 0xdb, 0x95, 0x41, 0xb9, 0x52, 0x3a, 0x4a, 0xb5, 0xbd, 0x6a, 0x14, 0x91, 0x36, 0x4d, 0xd2, 0xa4,
  0x88, 0xb5, 0xcc, 0xb3, 0x99, 0xa2, 0x53, 0xab, 0x6b, 0xcf, 0xcc, 0xb9, 0xb7, 0xdb, 0xec, 0x3e, 0xd6, 0x47, 0x20, 0xaf,
  0x56, 0xad, 0xe5, 0x2f, 0x5b, 0x35, 0x2c, 0xf6, 0xa5, 0xb7, 0xb4, 0xe1, 0x32, 0xdb, 0x4f, 0x29, 0x9a, 0x8c, 0xa7, 0xf4,
  0x02, 0xb9, 0x0c, 0x51, 0xa2, 0xcb, 0xe3, 0xb8, 0xba, 0x12, 0x56, 0x6d, 0x99, 0xbc, 0x33, 0xd5, 0x26, 0x8f, 0x2f, 0xc7,
  0x7c, 0xb2, 0x3b, 0xc7, 0xf5, 0xc4, 0x1c, 0xb3, 0x6f, 0xcd, 0x79, 0x5e, 0xd6, 0x54, 0x75, 0x83, 0x43, 0x8a, 0xca, 0xe6,
  0xbb, 0x5c, 0xd5, 0xbd, 0x27, 0x0e, 0xbf, 0xf6, 0x32, 0x3e, 0x43, 0xb8, 0x38, 0x10, 0x9c, 0x74, 0x9d, 0x01, 0x42, 0xf3,
  0x37, 0x3d, 0x8f, 0x92, 0x96, 0x9e, 0xd0, 0x0e, 0x4e, 0xe2, 0x7d, 0x36, 0x68, 0x32, 0x67, 0xad, 0xd9, 0x5e, 0xee, 0x83,
  0xa5, 0x5e, 0xd5, 0x78, 0xf5, 0x1f, 0x0a, 0x49, 0xbe, 0x7c, 0x50, 0x5c, 0x4b, 0x1a, 0xaa, 0xdb, 0x1b, 0xb9, 0xa1, 0x1a,
  0x1f, 0x25, 0x37, 0x2e, 0xdc, 0x55, 0x99, 0xa2, 0xb4, 0xd7, 0x93, 0xd0, 0x66, 0x72, 0x29, 0x0b, 0xa7, 0x33, 0xef, 0xf7,
  0xe5, 0x60, 0xba, 0xba, 0x93, 0x7d, 0xbd, 0x27, 0xea, 0x8f, 0x2d, 0x81, 0x2c, 0x1d, 0xe0, 0x15, 0xa8, 0x93, 0x3b, 0xf4,
  0xd8, 0x54, 0x17, 0xa7, 0x56, 0x6a, 0xef, 0xc3, 0x0f, 0x74, 0xeb, 0x3a, 0x3c, 0xd4, 0xf0, 0x4f, 0xe6, 0xd0, 0xbf, 0x8a,
  0xd1, 0x2a, 0xce, 0xda, 0x8d, 0x8d, 0x8d, 0x42, 0x64, 0xaa, 0x0c, 0xc0, 0x9d, 0x82, 0xa0, 0x54, 0x14, 0x70, 0xb3, 0x62,
  0x32, 0xd4, 0x54, 0x9e, 0x41, 0x9e, 0xc5, 0x57, 0x9f, 0x7d, 0xd0, 0xce, 0x43, 0x8a, 0x9b, 0x8b, 0xe4, 0x05, 0xa5, 0x52,
  0x38, 0x47, 0x8d, 0x75, 0x22, 0x7b, 0x22, 0xb2, 0x33, 0xaa, 0x30, 0xc1, 0xa9, 0xd4, 0xe5, 0x5b, 0x45, 0x2d, 0x2a, 0xa9,
  0x30, 0xa3, 0x7d, 0x23, 0xd4, 0xaf, 0x28, 0xd9, 0x47, 0x7e, 0x91, 0x41, 0xe0, 0x4a, 0x93, 0xdc, 0x31, 0x33, 0x45, 0x80,
  0xe0, 0xa5, 0xe0, 0x34, 0xf2, 0xf7, 0xf8, 0xf3, 0xc3, 0x84, 0x46, 0x01, 0x7c, 0x5d, 0x16, 0x3d, 0xbb, 0x7f, 0x5f, 0xda,
  0x4e, 0x38, 0x40, 0xdb, 0x78, 0xda, 0x99, 0x74, 0x32, 0x9e, 0x64, 0x08, 0xa7, 0x30, 0x6d, 0x8a, 0x9b, 0x96, 0x57, 0xb5,
  0xc9, 0xe9, 0x0a, 0x1a, 0x0f, 0xcf, 0xf0, 0xe0, 0xe8, 0x35, 0xc2, 0x92, 0xba, 0xde, 0x8d, 0xae, 0x2d, 0x98, 0xcc, 0x89,
  0x27, 0x33, 0x77, 0x1f, 0xca, 0x0b, 0xa7, 0x45, 0x96, 0x4d, 0x71, 0xcd, 0xa3, 0x7d, 0x6f, 0xa4, 0x4b, 0x59, 0xd0, 0xea,
  0x26, 0x98, 0x6f, 0x82, 0xf8, 0x82, 0x5c, 0x0e, 0xc5, 0x49, 0x27, 0xd2, 0xe3, 0xeb, 0xda, 0x6e, 0x68, 0xb8, 0xb6, 0xed,
  0x50, 0x3c, 0xc6, 0x02, 0xfa, 0xa6, 0x2e, 0x7c, 0x0e, 0xeb, 0xea, 0x4e, 0x79, 0x11, 0x3b, 0x9d, 0xbd, 0xe5, 0x9b, 0xaf,
  0x8a, 0xe5, 0x6f, 0x9c, 0x3a, 0x58, 0xa5, 0x0a, 0x31, 0x7d, 0x80, 0xe6, 0xcd, 0xc6, 0xe4, 0x12, 0xd4, 0x93, 0x81, 0x14,
  0x42, 0x51, 0x38, 0x0f, 0x18, 0x62, 0x19, 0x9a, 0x61, 0xa2, 0x25, 0x8f, 0x02, 0x28, 0xec, 0x73, 0xcb, 0x55, 0xca, 0xec,
  0x83, 0x94, 0x9c, 0xab, 0x78, 0xda, 0x8a, 0x49, 0xd2, 0xd4, 0xcb, 0x7b, 0x35, 0x98, 0xe4, 0x2f, 0x59, 0xee, 0x58, 0xda,
  0x07, 0x31, 0x8e, 0xc3, 0xba, 0x28, 0x62, 0x1c, 0x7b, 0xbb, 0x81, 0x76, 0x30, 0x27, 0x41, 0x79, 0x07, 0xb6, 0x84, 0x40,
  0x59, 0xf8, 0x09, 0x47, 0x38, 0xf6, 0x62, 0x4d, 0x07, 0x54, 0x52, 0xde, 0x9a, 0x57, 0xd7, 0x92, 0x5a, 0x93, 0xf3, 0xa9,
  0xd6, 0x59, 0xd7, 0x14, 0x18, 0xcc, 0x54, 0xf6, 0xf6, 0x9e, 0x93, 0xe6, 0x91, 0x9c, 0xf8, 0x02, 0x55, 0x38, 0x0b, 0xe7,
  0xdb, 0xed, 0x72, 0xe9, 0x81, 0x60, 0xed, 0x4b, 0x0c, 0xca, 0xe6, 0xe8, 0x24, 0xe4, 0xd4, 0xdb, 0xac, 0xd9, 0xb5, 0x59,
  0x8e, 0x2b, 0xc3, 0x7b, 0xa4, 0x9f, 0x47, 0x89, 0x4c, 0x86, 0x8a, 0xc6, 0xc7, 0x49, 0xc5, 0x8f, 0x12, 0x87, 0x0c, 0x1a,
  0x63, 0x51, 0x02, 0xf3, 0x86, 0x66, 0xa4, 0xd4, 0xca, 0x2b, 0x54, 0x59, 0x94, 0xd3, 0x4d, 0x39, 0xa8, 0x59, 0x69, 0x4d,
  0xe8, 0x60, 0x27, 0xfd, 0x5c, 0x44, 0x33, 0x60, 0xeb, 0xfc, 0xa2, 0x52, 0x11, 0x5e, 0x6b, 0x55, 0x1c, 0x08, 0x12, 0xee,
  0xff, 0xe3, 0xff, 0x52, 0xfd, 0xb3, 0x7f, 0xdb, 0xdd, 0x35, 0xe0, 0x6f, 0x5b, 0xfc, 0xad, 0xbd, 0x77, 0xde, 0x7d, 0xa8,
  0xd2, 0xcf, 0x91, 0xf6, 0xb7, 0x76, 0x2c, 0x12, 0x7d, 0xfb, 0xa6, 0x80, 0x7a, 0xa8, 0xd0, 0x5a, 0x67, 0x09, 0x52, 0xda,
  0x87, 0xfd, 0x42, 0xc9, 0x72, 0xaf, 0xe0, 0xc9, 0x10, 0x4c, 0xc2, 0x9c, 0xbd, 0x96, 0x0f, 0xe8, 0xc8, 0x93, 0x39, 0xa3,
  0x4a, 0xa3, 0x31, 0xa2, 0xff, 0x11, 0x3c, 0x11, 0x27, 0xb3, 0x59, 0x61, 0xc3, 0x78, 0xbd, 0xf0, 0x6e, 0x9e, 0xc3, 0x97,
  0xaa, 0x5e, 0xd7, 0xfd, 0x30, 0x52, 0x07, 0x1c, 0xe7, 0x57, 0xb9, 0x54, 0xb2, 0x98, 0xfb, 0xf1, 0xca, 0xdb, 0x04, 0x1f,
  0x2f, 0x51, 0x2d, 0x05, 0x2c, 0xfe, 0xfd, 0xe1, 0x6d, 0xfe, 0xed, 0xce, 0x78, 0x49, 0xc9, 0xf7, 0xce, 0x2a, 0x4e, 0xe5,
  0x71, 0xf6, 0x25, 0xde, 0x58, 0xfe, 0xfb, 0xa8, 0xf2, 0xc7, 0x56, 0xd3, 0x75, 0xde, 0x74, 0x44, 0x78, 0x28, 0x66, 0xbd,
  0xfd, 0x13, 0xab, 0x06, 0x7a, 0xdf, 0x55, 0x5a, 0x00, 0xe0, 0x4d, 0x16, 0xf8, 0x9e, 0x55, 0xe4, 0xcf, 0xba, 0xa3, 0x3e,
  0x3b, 0xd5, 0xa7, 0x2f, 0xde, 0xbe, 0xab, 0x3b, 0xbf, 0xbe, 0x7b, 0xf6, 0xd8, 0x6d, 0xd5, 0x2a, 0x94, 0xf3, 0xb9, 0x29,
  0x22, 0xf6, 0x48, 0x64, 0xf8, 0x08, 0xea, 0xb3, 0x03, 0x12, 0xda, 0xe3, 0x2a, 0x03, 0xfa, 0xec, 0x77, 0x8c, 0x07, 0x16,
  0x97, 0x36, 0x3f, 0xbc, 0xe5, 0x1f, 0xa7, 0xad, 0xb3, 0xca, 0x63, 0xba, 0x5b, 0x5d, 0xbe, 0xd9, 0x21, 0x91, 0xfe, 0x3d,
  0x05, 0x53, 0x08, 0xc2, 0xda, 0x2b, 0xc4, 0xb8, 0x77, 0x77, 0x5c, 0x16, 0xac, 0xa8, 0x29, 0x42, 0x7a, 0x3d, 0x7c, 0x65,
  0x0e, 0xeb, 0xf0, 0xf1, 0x5c, 0x44, 0xcb, 0x80, 0x6f, 0xb2, 0xce, 0x26, 0x0e, 0x96, 0x3b, 0x00, 0xb0, 0xf4, 0xef, 0x7f,
  0xfb, 0x77, 0x1a, 0x03, 0x17, 0xfe, 0x93, 0x7d, 0x04, 0x69, 0x81, 0xb7, 0x89, 0x05, 0x85, 0x34, 0x83, 0xa8, 0x66, 0xf4,
  0x54, 0xfb, 0x73, 0x06, 0xdb, 0xf0, 0x13, 0x94, 0xa2, 0x7f, 0x55, 0x41, 0x61, 0x93, 0xaf, 0x20, 0xdf, 0x41, 0x45, 0x72,
  0xf2, 0x3e, 0xcd, 0xba, 0xf4, 0x57, 0xb2, 0x9c, 0xfc, 0x18, 0x2d, 0x7c, 0x54, 0x38, 0x2b, 0x1f, 0x9a, 0x1c, 0x46, 0x89,
  0x71, 0xe4, 0xd8, 0x86, 0x4a, 0x8a, 0xfc, 0x0c, 0x9f, 0xb2, 0x2a, 0x2c, 0xbe, 0x93, 0x49, 0x0b, 0xf1, 0x37, 0x1b, 0x5b,
  0xe9, 0xa7, 0xec, 0xcb, 0x4c, 0x3d, 0x3c, 0xb6, 0x27, 0x9b, 0x56, 0xe3, 0x27, 0x7a, 0x08, 0x43, 0xe3, 0x89, 0xe2, 0x13,
  0x5b, 0xc4, 0x7c, 0x9e, 0x48, 0xa5, 0xbe, 0xf1, 0xae, 0x58, 0x9b, 0xce, 0x96, 0x48, 0xf5, 0x67, 0xb2, 0x8b, 0xe3, 0x3b,
  0x9c, 0xd9, 0x55, 0x3c, 0x91, 0x6d, 0x3e, 0x7a, 0x94, 0x56, 0x06, 0x9c, 0x36, 0xca, 0x9d, 0x55, 0xe8, 0x1e, 0x4d, 0xe2,
  0xa4, 0x98, 0xf0, 0x10, 0x2d, 0xd4, 0x48, 0x11, 0xd1, 0x46, 0x5d, 0x15, 0x8e, 0x59, 0xa6, 0xfd, 0xdb, 0x95, 0x0c, 0xc5,
  0x06, 0xf4, 0x56, 0x0d, 0xd6, 0x55, 0xf1, 0xc9, 0xf1, 0x9f, 0xa7, 0xea, 0xe1, 0xcf, 0xd3, 0xe3, 0x90, 0xcd, 0xc9, 0x57,
  0x71, 0xad, 0xce, 0x69, 0x73, 0xb1, 0x40, 0x95, 0x7f, 0x7e, 0x0e, 0x50, 0x10, 0xfa, 0xbc, 0x92, 0xfe, 0x24, 0x99, 0xbf,
  0x0b, 0x78, 0x9b, 0x51, 0x33, 0xdd, 0xa4, 0xb6, 0x2b, 0x40, 0x09, 0x10, 0xc2, 0x40, 0x77, 0xa6, 0xe7, 0x33, 0x1a, 0x71,
  0x2f, 0x67, 0xf2, 0x3a, 0xcb, 0x91, 0x1a, 0xd7, 0x59, 0x55, 0x02, 0xe5, 0xec, 0xf7, 0xe7, 0x6a, 0xa2, 0x84, 0xf1, 0xf2,
  0x03, 0x12, 0x09, 0xf5, 0xa9, 0x52, 0x1b, 0x51, 0x2f, 0x98, 0x31, 0x65, 0x16, 0x2d, 0xd7, 0xe8, 0x22, 0x3e, 0x23, 0x1c,
  0xa2, 0x10, 0x7b, 0x78, 0x5d, 0xe1, 0xfb, 0x70, 0x05, 0x38, 0x55, 0x30, 0x1b, 0x0e, 0x8b, 0x91, 0xc2, 0x3a, 0x4a, 0xbc,
  0xba, 0x29, 0xf0, 0xfc, 0x9b, 0xec, 0x67, 0x36, 0xba, 0x33, 0xe6, 0x48, 0x69, 0x9f, 0x40, 0x24, 0xd7, 0x5e, 0x4d, 0x84,
  0xef, 0x08, 0x65, 0x86, 0xac, 0x46, 0x3b, 0xba, 0x8a, 0xb5, 0x70, 0x6a, 0xab, 0xeb, 0x47, 0x6b, 0x4d, 0xee, 0xb8, 0xdf,
  0x0e, 0x2d, 0x4c, 0x8f, 0xcf, 0xf3, 0x9b, 0x53, 0x82, 0x4e, 0xdc, 0x1c, 0x95, 0xde, 0xc8, 0xc3, 0x18, 0x85, 0xf9, 0xa8,
  0x37, 0xbe, 0xf0, 0x17, 0xaa, 0x0e, 0xbf, 0xa6, 0x1d, 0x23, 0x64, 0x50, 0x03, 0xb3, 0xb9, 0x4c, 0xcf, 0x81, 0xaa, 0x18,
  0x8b, 0xe4, 0x93, 0x11, 0xd6, 0x52, 0xd2, 0xb8, 0x38, 0x2b, 0xbd, 0xdc, 0x39, 0x33, 0xbc, 0x1c, 0x56, 0xed, 0xe9, 0xf2,
  0x17, 0xb6, 0x1c, 0x55, 0xcc, 0x46, 0xdf, 0x6e, 0xa7, 0x77, 0x9b, 0xf6, 0x4d, 0x90, 0x54, 0x38, 0xd4, 0xca, 0x10, 0x7b,
  0x1e, 0x3d, 0x52, 0xac, 0x1d, 0x7e, 0xeb, 0x2a, 0x03, 0x1d, 0xd4, 0x29, 0x32, 0x5b, 0xa1, 0x84, 0x68, 0x5a, 0xe6, 0x59,
  0x9d, 0x4a, 0x1b, 0xcb, 0x48, 0xee, 0xa8, 0x40, 0xc9, 0x9b, 0x06, 0x44, 0x89, 0x51, 0x5a, 0x78, 0xc7, 0x27, 0x2a, 0x49,
  0x50, 0x13, 0x6a, 0x84, 0x94, 0xe0, 0x6c, 0x61, 0x52, 0x9a, 0x7a, 0x44, 0xb7, 0xff, 0x88, 0x4e, 0x64, 0x46, 0x5a, 0x49,
  0x0d, 0x37, 0x42, 0xd1, 0x99, 0x64, 0x35, 0x9f, 0x7a, 0x8c, 0x36, 0x41, 0xd8, 0x6a, 0x93, 0xc7, 0x8f, 0x79, 0x50, 0x78,
  0x6a, 0xe9, 0xad, 0x78, 0x59, 0xc7, 0x78, 0x91, 0x5c, 0x30, 0x0e, 0x97, 0xab, 0x90, 0xe0, 0x28, 0xab, 0xdf, 0x9f, 0x4c,
  0xf2, 0xd5, 0x31, 0x3d, 0x0c, 0x77, 0x73, 0x7f, 0x92, 0xeb, 0x59, 0x1e, 0x60, 0xe7, 0x6c, 0x62, 0x5a, 0x2c, 0x56, 0x42,
  0xb6, 0x1e, 0x34, 0x7a, 0x4f, 0x30, 0xe5, 0x2f, 0x00, 0x3c, 0x6b, 0x9a, 0xae, 0x8d, 0xf3, 0x86, 0x8f, 0xe2, 0xc8, 0x2f,
  0xb1, 0x40, 0x46, 0xcb, 0x1c, 0x32, 0x25, 0x61, 0xce, 0x53, 0xf9, 0x86, 0xf6, 0x6f, 0x7b, 0x5f, 0xca, 0xd8, 0x5e, 0xdc,
  0x9d, 0xfd, 0x32, 0x28, 0x4b, 0x73, 0xf9, 0xeb, 0x24, 0xf4, 0x23, 0x26, 0xc2, 0x19, 0x63, 0xd4, 0xb3, 0x78, 0xa3, 0x04,
  0x16, 0x52, 0xde, 0x26, 0x5c, 0x69, 0x36, 0xd7, 0x6b, 0xa6, 0xfb, 0x71, 0x00, 0x6b, 0xe3, 0x70, 0x20, 0x8f, 0xa3, 0x4a,
  0x00, 0x82, 0xe2, 0xef, 0x6c, 0x32, 0x32, 0xcb, 0x3b, 0xe1, 0x8e, 0xa7, 0x2f, 0xd6, 0xbc, 0xa5, 0x85, 0x5f, 0xf4, 0x9a,
  0x96, 0xbb, 0xc2, 0x0a, 0xde, 0xa7, 0xe9, 0xde, 0x60, 0x06, 0x54, 0x68, 0x7c, 0xcf, 0x7a, 0x33, 0x01, 0x97, 0xe0, 0x4c,
  0xfb, 0x5a, 0x0a, 0x50, 0x69, 0xc8, 0xc6, 0x77, 0x28, 0x24, 0x8c, 0xbf, 0xd2, 0xdc, 0xfd, 0xb5, 0x96, 0x6a, 0xe6, 0x3d,
  0x16, 0x43, 0x70, 0x9a, 0xaa, 0x44, 0xea, 0xd7, 0x3f, 0xaf, 0x95, 0x51, 0xa0, 0xe0, 0x02, 0xe5, 0xb1, 0xd5, 0x0c, 0x6a,
  0xb4, 0x84, 0xef, 0x0a, 0x1b, 0xc2, 0x8f, 0x69, 0x3b, 0x19, 0xf3, 0xf2, 0x97, 0x0f, 0xc8, 0x34, 0xae, 0x7e, 0xc1, 0x70,
  0x38, 0x08, 0xfc, 0xeb, 0xc3, 0x3d, 0x4a, 0x6f, 0x44, 0x55, 0x78, 0xb4, 0xcf, 0x8f, 0x44, 0x43, 0xfa, 0xd6, 0x4e, 0xad,
  0xff, 0xc5, 0xee, 0x27, 0xab, 0xe5, 0x49, 0x67, 0x37, 0x85, 0x46, 0xf0, 0x71, 0x11, 0x27, 0x13, 0xc4, 0x9f, 0xb6, 0xab,
  0x9d, 0xab, 0x7d, 0xef, 0xc5, 0x18, 0x68, 0x87, 0x96, 0x40, 0x52, 0x37, 0x79, 0x0b, 0x21, 0xe0, 0xf2, 0x86, 0xf3, 0x71,
  0x7a, 0xdc, 0x96, 0x53, 0x3b, 0x72, 0x11, 0xcc, 0x73, 0xa9, 0x1b, 0xe2, 0xcb, 0xcc, 0x17, 0xa8, 0x54, 0x94, 0x59, 0x2f,
  0xe4, 0x75, 0x37, 0x32, 0x49, 0xec, 0xaf, 0x22, 0x04, 0x25, 0xa2, 0x81, 0xa4, 0x71, 0x30, 0x23, 0xd0, 0x94, 0xcb, 0x2f,
  0x32, 0x80, 0x59, 0x80, 0xa8, 0x1a, 0x47, 0x2b, 0xba, 0x5c, 0x65, 0x43, 0x3f, 0x75, 0x43, 0x72, 0x3c, 0xb9, 0x6d, 0x8d,
  0x52, 0x4d, 0xcb, 0x05, 0xb9, 0x87, 0xee, 0x8b, 0x8d, 0xe0, 0xa1, 0x3d, 0xaa, 0xbc, 0xb8, 0x4e, 0x82, 0x0d, 0x9e, 0x13,
  0x11, 0x97, 0x3a, 0x74, 0x46, 0x95, 0xb7, 0xd1, 0x3c, 0x41, 0xbd, 0x5c, 0xbe, 0xea, 0x42, 0x15, 0x6f, 0x15, 0xce, 0x9c,
  0x63, 0x27, 0xb8, 0x9e, 0x05, 0x74, 0xb0, 0xa4, 0x52, 0xef, 0x8d, 0x2a, 0x18, 0x79, 0xb8, 0xd9, 0x6c, 0xd7, 0x42, 0x06,
  0xf6, 0xa3, 0xf3, 0x4a, 0xbd, 0x3f, 0xaa, 0xbc, 0xf3, 0xe2, 0x4f, 0xda, 0x9b, 0xc1, 0xa8, 0xf2, 0x73, 0x02, 0x3a, 0x82,
  0xf6, 0x6a, 0x88, 0x22, 0x7c, 0xb0, 0x76, 0xe2, 0x05, 0x1f, 0xfa, 0xf8, 0x04, 0x62, 0xdf, 0xc9, 0xe8, 0xff, 0x6f, 0xed,
  0x58, 0x9b, 0x9b, 0x36, 0x82, 0xdf, 0xf9, 0x15, 0xea, 0x0c, 0x8d, 0xa4, 0x22, 0x8c, 0x53, 0x98, 0xce, 0x34, 0x8e, 0xe3,
  0x31, 0x10, 0x53, 0xb7, 0x09, 0xe9, 0xe0, 0xc0, 0x17, 0x37, 0x63, 0x3b, 0x96, 0x42, 0x0c, 0x76, 0xe4, 0xb1, 0xe4, 0x40,
  0x27, 0xd1, 0x7f, 0xef, 0xbe, 0xee, 0x25, 0x9d, 0x69, 0xca, 0xf4, 0x0b, 0x44, 0xa7, 0xbd, 0xbd, 0xbb, 0xd5, 0xf9, 0x6e,
  0xdf, 0x0b, 0x82, 0x3b, 0x4c, 0x31, 0xdf, 0xc2, 0x90, 0xfb, 0x30, 0xe5, 0xd1, 0xeb, 0xe1, 0x99, 0x9a, 0xc2, 0x3e, 0x4c,
  0xfb, 0xfd, 0xe8, 0xa5, 0x7e, 0x84, 0x89, 0xff, 0x7e, 0xde, 0x7f, 0xa3, 0x9f, 0x61, 0xd6, 0xd9, 0x60, 0x0b, 0x97, 0x0b,
  0x09, 0x2e, 0xd0, 0xf0, 0x42, 0x2d, 0xf3, 0xe3, 0x12, 0x33, 0x14, 0x41, 0x0b, 0xcc, 0xf7, 0xd5, 0x9f, 0xef, 0x03, 0x14,
  0x01, 0xb7, 0xeb, 0x50, 0xe7, 0x56, 0x23, 0x12, 0x8d, 0x99, 0x6c, 0x17, 0xf7, 0xf7, 0x53, 0xe5, 0x26, 0x16, 0x3d, 0xbe,
  0xe3, 0xc6, 0x5e, 0x2f, 0xb4, 0x1d, 0xd6, 0xaa, 0x78, 0xda, 0xd4, 0xa5, 0xd5, 0xf7, 0xa3, 0x66, 0x94, 0xc8, 0x81, 0x68,
  0x87, 0x2a, 0x1c, 0x4e, 0x9c, 0x12, 0x1d, 0x04, 0xd1, 0xca, 0xa1, 0xa2, 0x4d, 0x92, 0x07, 0x78, 0xa3, 0x59, 0x72, 0xbd,
  0x1a, 0xd8, 0x39, 0xe9, 0xa6, 0x87, 0x70, 0x73, 0xe4, 0xc0, 0xc5, 0x18, 0xbf, 0x31, 0x4f, 0x66, 0x51, 0xa7, 0x06, 0xa0,
  0xf6, 0x92, 0x0a, 0x31, 0xd1, 0x15, 0xf7, 0x3e, 0xbc, 0xdc, 0x1c, 0x4d, 0x9f, 0x44, 0xec, 0x02, 0x25, 0x1e, 0xa4, 0xfc,
  0xa0, 0x32, 0x98, 0x3d, 0xbe, 0x5b, 0x95, 0x26, 0x4c, 0xa5, 0xb2, 0xe3, 0xa7, 0x6d, 0xe7, 0x47, 0xf2, 0x59, 0x7e, 0xb2,
  0x5f, 0x61, 0x52, 0x2d, 0xe4, 0xf0, 0x27, 0xc4, 0x7f, 0xf7, 0x42, 0x84, 0x37, 0xc2, 0xac, 0x62, 0xca, 0xc3, 0x6a, 0xca,
  0x56, 0x82, 0xac, 0x98, 0xab, 0xe4, 0x4c, 0x38, 0x15, 0x2c, 0x36, 0x04, 0xdc, 0xb7, 0xe5, 0x97, 0x65, 0x72, 0xa4, 0xba,
  0x21, 0x3e, 0x9c, 0x96, 0xf3, 0xfd, 0x1a, 0x49, 0x1d, 0xa9, 0x90, 0x0d, 0x5f, 0x6a, 0x22, 0xf5, 0x8e, 0x19, 0x4f, 0x09,
  0xa2, 0xe0, 0x4a, 0x7c, 0x26, 0xce, 0x61, 0x80, 0x69, 0xdf, 0xb2, 0x48, 0x05, 0x40, 0xd0, 0xff, 0x87, 0xca, 0x2e, 0x16,
  0x38, 0x45, 0x33, 0x44, 0x1e, 0x2c, 0xf3, 0x72, 0xb6, 0xec, 0x5a, 0xb1, 0x26, 0x12, 0x0d, 0x23, 0x5d, 0x80, 0x6c, 0xd6,
  0x3b, 0x02, 0xe6, 0x10, 0x94, 0x0a, 0x09, 0xd7, 0x8c, 0x99, 0x23, 0x08, 0x13, 0x23, 0xd7, 0x5a, 0xcf, 0x52, 0xaa, 0x79,
  0x17, 0xfd, 0x9c, 0x84, 0xed, 0x30, 0xae, 0x56, 0xa6, 0x17, 0x83, 0x02, 0x54, 0x03, 0xa8, 0x68, 0x6e, 0xda, 0xba, 0x3a,
  0x97, 0xc3, 0x21, 0x1e, 0x58, 0x5c, 0xe9, 0xfe, 0xfe, 0x81, 0xb5, 0x95, 0x3c, 0x80, 0xd6, 0x0d, 0xa7, 0x0a, 0x30, 0x29,
  0x01, 0x6c, 0x44, 0x03, 0x79, 0x14, 0x8d, 0xbb, 0x8b, 0x30, 0xa1, 0x96, 0xd7, 0x37, 0x74, 0x2f, 0xe4, 0xe2, 0x3e, 0xd2,
  0xa8, 0xcb, 0x8f, 0x59, 0x03, 0x2b, 0x10, 0x2a, 0xbc, 0x83, 0xbe, 0x7a, 0x7f, 0x18, 0x7d, 0x15, 0x74, 0x31, 0x1a, 0xda,
  0x9b, 0x72, 0x3d, 0x41, 0xc4, 0xb0, 0x49, 0x68, 0xb3, 0x34, 0x96, 0xb4, 0xa5, 0xcd, 0x86, 0xef, 0xad, 0xc5, 0xf0, 0x0e,
  0xac, 0x7b, 0x76, 0x72, 0x2b, 0x3a, 0x75, 0x3a, 0xfb, 0x34, 0x6d, 0x19, 0x1c, 0x31, 0x25, 0x1d, 0xd0, 0xf3, 0x38, 0xa1,
  0x6c, 0x68, 0xf5, 0x0d, 0x89, 0xe6, 0xc6, 0xbd, 0x3d, 0xf8, 0x17, 0x84, 0x95, 0x1e, 0x3e, 0x1d, 0xfe, 0xd2, 0xee, 0xb9,
  0x7b, 0x0b, 0x41, 0xaa, 0xa0, 0x00, 0x1c, 0xf9, 0xf4, 0x00, 0x21, 0x28, 0x3e, 0xa8, 0x01, 0x83, 0xdb, 0x8a, 0xd4, 0x86,
  0x0c, 0xd8, 0x7c, 0xcf, 0xbb, 0x33, 0xb8, 0xa6, 0xf7, 0xfc, 0x33, 0xb4, 0x84, 0x60, 0x95, 0xde, 0x5c, 0x64, 0xe0, 0x06,
  0x6d, 0x2c, 0xe2, 0xa1, 0x5c, 0x8b, 0x2c, 0x72, 0xbe, 0x85, 0xbb, 0x1e, 0x6f, 0xb7, 0xba, 0xa3, 0xaa, 0x2c, 0x56, 0xe9,
  0x43, 0x4f, 0x44, 0xf0, 0xde, 0x01, 0x56, 0xf9, 0x07, 0x64, 0x15, 0x23, 0x5d, 0x04, 0x93, 0x0c, 0xb5, 0x70, 0xea, 0xab,
  0xd0, 0x0b, 0x32, 0xf1, 0xd5, 0x10, 0xea, 0x0f, 0xed, 0xe9, 0x1a, 0x1f, 0x75, 0x7f, 0x6d, 0x63, 0x58, 0x95, 0xba, 0x41,
  0x0f, 0xbe, 0x09, 0xdd, 0x2a, 0xf3, 0xc1, 0xe2, 0x2b, 0xb0, 0x4e, 0xcf, 0xe3, 0x27, 0x61, 0x50, 0xec, 0x22, 0xca, 0x75,
  0x36, 0x5b, 0x4f, 0xae, 0x36, 0x99, 0xf8, 0x04, 0xe0, 0xe3, 0x6f, 0x79, 0x63, 0xb3, 0x5c, 0xad, 0x4a, 0x2c, 0x1e, 0x50,
  0xc0, 0x58, 0xba, 0x83, 0x7f, 0x03, 0xc2, 0x25, 0x57, 0x2e, 0xb3, 0xab, 0x62, 0x42, 0x47, 0x00, 0x23, 0xbd, 0x2a, 0x3c,
  0x28, 0xd3, 0x96, 0x0b, 0xca, 0x31, 0x71, 0x1b, 0xf4, 0x03, 0x8f, 0xf6, 0xdb, 0xed, 0x9f, 0xac, 0xf7, 0x70, 0x9d, 0xa6,
  0xcf, 0xea, 0xf0, 0xb0, 0xaa, 0x1f, 0xe1, 0xa7, 0x42, 0x1a, 0x63, 0xff, 0xd2, 0xe0, 0xce, 0x32, 0xea, 0xc2, 0x09, 0x46,
  0x10, 0xac, 0x80, 0xe7, 0xd6, 0xcc, 0xb2, 0x7e, 0x6e, 0xaa, 0x0a, 0x3d, 0xdd, 0x3a, 0x3b, 0x46, 0xc0, 0x5c, 0x13, 0xe9,
  0x84, 0xf4, 0x2f, 0x06, 0xf5, 0xfc, 0xb3, 0x17, 0xad, 0x0d, 0xdb, 0xd9, 0xe9, 0x42, 0xc9, 0x89, 0x32, 0xf8, 0x6b, 0x16,
  0xb2, 0x51, 0x2f, 0xcb, 0x63, 0x79, 0x6c, 0x62, 0xad, 0xf5, 0xe8, 0x58, 0xe0, 0x5e, 0xb2, 0x37, 0xbb, 0x54, 0xf6, 0xa5,
  0xc5, 0xb6, 0xc2, 0xd7, 0xba, 0xce, 0x8d, 0x53, 0xed, 0x39, 0x61, 0x1d, 0xf2, 0x48, 0xaa, 0x22, 0x89, 0xc9, 0x97, 0xc8,
  0x8f, 0x95, 0x71, 0x40, 0xdc, 0x59, 0x2d, 0x80, 0x2f, 0x54, 0xc5, 0x17, 0x4d, 0x13, 0xb1, 0xef, 0x84, 0x68, 0x6f, 0x2f,
  0x9a, 0x73, 0xd8, 0xc0, 0x87, 0x45, 0xf6, 0xe5, 0x87, 0x6e, 0x37, 0x9c, 0xa5, 0xb7, 0x33, 0xd2, 0x89, 0xc2, 0x09, 0xaa,
  0x3c, 0x29, 0x38, 0x2e, 0x00, 0xd5, 0x12, 0x1b, 0x3a, 0x9d, 0xe0, 0x7d, 0x0b, 0x36, 0x7d, 0x14, 0x3f, 0x45, 0xa4, 0xfd,
  0xf2, 0xf0, 0xf5, 0xb0, 0xff, 0xe6, 0xed, 0xd9, 0xe8, 0x7c, 0xf8, 0x6a, 0x34, 0x19, 0xbe, 0x3d, 0x3f, 0x7e, 0xf7, 0xa1,
  0x7f, 0x32, 0x39, 0x1d, 0xa9, 0x18, 0xb8, 0x40, 0xc6, 0x6d, 0xc1, 0x52, 0xf3, 0x25, 0xb1, 0xff, 0xdc, 0xb1, 0xdb, 0xc0,
  0x88, 0x39, 0xa1, 0xcc, 0x44, 0xbb, 0x11, 0xb1, 0xec, 0x98, 0xc0, 0xfb, 0xce, 0x89, 0xdd, 0xe2, 0x18, 0xe4, 0x42, 0x94,
  0x46, 0x0a, 0xfd, 0x6c, 0xb9, 0x44, 0x69, 0x04, 0x8b, 0x30, 0x8d, 0x8d, 0x22, 0xc9, 0x54, 0x09, 0x82, 0x2f, 0x56, 0xa3,
  0x59, 0xaf, 0x3e, 0x33, 0xf7, 0x75, 0x7c, 0xb0, 0xce, 0x01, 0x27, 0xab, 0xfd, 0x63, 0x5d, 0x80, 0x56, 0x14, 0xe3, 0x32,
  0x09, 0x1d, 0x97, 0xf5, 0xb5, 0x25, 0xf5, 0xce, 0x81, 0x8c, 0x9b, 0xec, 0x93, 0x54, 0x95, 0xa4, 0x92, 0xd9, 0xd4, 0x41,
  0x02, 0x18, 0xa5, 0x1a, 0x1d, 0xb3, 0x91, 0x82, 0x71, 0x9c, 0x26, 0xc5, 0x85, 0x46, 0x28, 0x9c, 0xd4, 0x57, 0x13, 0x30,
  0x4b, 0x86, 0x06, 0xdc, 0x06, 0xff, 0xd9, 0xec, 0xaa, 0x49, 0x86, 0xca, 0xea, 0xa2, 0x3b, 0x1e, 0x87, 0x03, 0xd8, 0x26,
  0x4f, 0xc9, 0x72, 0xf0, 0xf2, 0x5c, 0x58, 0xbc, 0x20, 0xb2, 0x58, 0xc1, 0x38, 0x4c, 0x8a, 0x3a, 0x8b, 0x39, 0x3d, 0xbb,
  0x61, 0x75, 0x7b, 0x61, 0x1b, 0x74, 0x9a, 0x9e, 0xed, 0xa8, 0x85, 0xc7, 0x72, 0x40, 0x17, 0xc9, 0x58, 0x55, 0xaa, 0x3f,
  0x0f, 0x8c, 0x23, 0x6d, 0xf1, 0x7d, 0xb6, 0x51, 0x07, 0x1b, 0xeb, 0x2f, 0xc2, 0x24, 0x2a, 0xbe, 0xdf, 0x44, 0x0a, 0x67,
  0x30, 0x3c, 0x11, 0xde, 0x81, 0x58, 0x1b, 0x51, 0xc1, 0xac, 0x2c, 0x8f, 0xd8, 0x4e, 0xf6, 0x15, 0x92, 0x23, 0x02, 0xfe,
  0x52, 0x61, 0x52, 0x17, 0xaa, 0xf0, 0x1b, 0x22, 0x62, 0x11, 0xae, 0xb8, 0xd7, 0xe6, 0x63, 0x86, 0x3b, 0x04, 0x8e, 0xe4,
  0x00, 0x0f, 0xe7, 0xe0, 0x92, 0xec, 0x50, 0x89, 0x1c, 0xd5, 0x18, 0xcd, 0x0c, 0xbb, 0x34, 0x9f, 0xc3, 0x0c, 0xa8, 0x32,
  0x0b, 0xcd, 0xe1, 0x24, 0xcf, 0xd7, 0x18, 0x46, 0x00, 0x4c, 0x07, 0x4c, 0x6b, 0xb1, 0xda, 0xae, 0x08, 0x01, 0xf6, 0x82,
  0xdb, 0x76, 0x3d, 0xa1, 0x57, 0x38, 0x7f, 0x3a, 0xea, 0xdd, 0xae, 0x58, 0xf4, 0x07, 0x05, 0xab, 0x1d, 0xdd, 0xe1, 0x88,
  0x73, 0x7b, 0x33, 0x2b, 0xdb, 0x73, 0x38, 0xd4, 0x03, 0x1f, 0xa0, 0x33, 0xcc, 0x40, 0xb3, 0x5a, 0x4c, 0xa7, 0xdd, 0x8c,
  0x97, 0x83, 0xb9, 0x63, 0xa7, 0x19, 0xe0, 0x52, 0x5a, 0x12, 0x37, 0xc2, 0x05, 0x27, 0x71, 0x64, 0x3f, 0x97, 0x36, 0x32,
  0x75, 0x1b, 0x3b, 0x52, 0x7a, 0xd1, 0x54, 0x5c, 0x84, 0x9b, 0xe6, 0x94, 0x6b, 0x4c, 0xd2, 0xe4, 0x84, 0xa3, 0x4a, 0x76,
  0x73, 0x4e, 0x08, 0xf5, 0x4a, 0x7d, 0x08, 0xcb, 0xd6, 0x88, 0xed, 0xc8, 0xa8, 0x20, 0x27, 0x98, 0x38, 0x0c, 0x1d, 0xdd,
  0xd2, 0xf8, 0xfa, 0x18, 0x0e, 0x0e, 0xc0, 0x8a, 0x59, 0x0c, 0xb0, 0x9f, 0x92, 0x24, 0x1f, 0x76, 0xdb, 0xbf, 0x88, 0x35,
  0x1e, 0x1c, 0x86, 0x4f, 0xf3, 0x42, 0x0d, 0x45, 0x76, 0x40, 0x0a, 0xf3, 0x56, 0x00, 0xf3, 0xd9, 0x4d, 0x4a, 0xe1, 0xbd,
  0x94, 0x35, 0x66, 0x61, 0x40, 0xf5, 0x8b, 0x89, 0xbc, 0xd8, 0xf1, 0x19, 0xbd, 0xb0, 0x30, 0x87, 0x67, 0xc1, 0x73, 0x3d,
  0x0b, 0xd8, 0xae, 0x73, 0xe0, 0x44, 0x8b, 0x05, 0x65, 0x9f, 0x52, 0x23, 0xb8, 0xad, 0x3d, 0x17, 0xb3, 0xea, 0xba, 0x40,
  0xc9, 0x1e, 0x0e, 0x25, 0xd5, 0x49, 0x3d, 0x3b, 0x14, 0x63, 0xbe, 0x39, 0x31, 0xd5, 0x47, 0xa7, 0xaa, 0xd8, 0x2f, 0x1f,
  0x21, 0xfe, 0x0a, 0xb3, 0x70, 0x72, 0x34, 0x2a, 0x01, 0x4f, 0x75, 0x25, 0x60, 0xd5, 0x53, 0x0a, 0xcf, 0xca, 0x31, 0x43,
  0xaa, 0x12, 0x3d, 0x64, 0x40, 0x3c, 0xbc, 0x71, 0x3f, 0x86, 0x45, 0xe7, 0x97, 0x94, 0x2f, 0x0b, 0x33, 0x52, 0xd8, 0x6c,
  0xbe, 0x06, 0xf1, 0x52, 0x71, 0xaa, 0x07, 0xaa, 0x41, 0x5b, 0x65, 0x11, 0x2b, 0x40, 0x5e, 0x03, 0x53, 0x63, 0xd9, 0x50,
  0xd3, 0xfa, 0xe4, 0x58, 0xb2, 0x49, 0x7c, 0x42, 0xc7, 0xe8, 0x7a, 0xcb, 0xe1, 0xfe, 0x6a, 0xd7, 0x53, 0x14, 0x1e, 0xa6,
  0x43, 0x92, 0x1f, 0x4b, 0x20, 0x0a, 0x37, 0xb2, 0x8a, 0x79, 0x16, 0xce, 0xe5, 0x13, 0x7c, 0xc8, 0x79, 0x93, 0x79, 0xbe,
  0xe9, 0x40, 0x1d, 0x53, 0xfa, 0x80, 0x6a, 0xfc, 0xf2, 0x4f, 0xad, 0x13, 0xc5, 0x05, 0xf5, 0x9f, 0x47, 0xc4, 0x16, 0x0e,
  0x46, 0x61, 0x42, 0x64, 0x74, 0xb8, 0x46, 0x45, 0x34, 0x97, 0x75, 0xac, 0xb8, 0x37, 0x91, 0xea, 0xe5, 0xc9, 0xb1, 0x54,
  0x9f, 0x11, 0x7b, 0x1f, 0x3f, 0x48, 0x24, 0x42, 0x2f, 0xec, 0x73, 0x44, 0xc2, 0x41, 0x38, 0x4c, 0x65, 0x05, 0xd8, 0x43,
  0x36, 0x4c, 0x01, 0xe8, 0x89, 0xa9, 0x63, 0x03, 0x1c, 0x3e, 0xde, 0xe4, 0x25, 0x90, 0x82, 0x23, 0xb3, 0xf1, 0x59, 0xd8,
  0x38, 0x9e, 0x9b, 0x9f, 0xb5, 0x54, 0x93, 0xac, 0x71, 0x88, 0x56, 0xb3, 0x83, 0xd4, 0x6a, 0xaf, 0xf3, 0x71, 0x7a, 0x45,
  0xa2, 0xcd, 0x80, 0x13, 0xec, 0x76, 0x91, 0xa2, 0xc5, 0x4a, 0x19, 0x33, 0xa5, 0x7d, 0xa2, 0xda, 0xf5, 0xbd, 0x63, 0xc9,
  0x51, 0xaa, 0x0e, 0x5c, 0x24, 0x17, 0x69, 0x2c, 0x9d, 0x1b, 0xbe, 0x06, 0xb8, 0x27, 0x8c, 0xad, 0x55, 0xa3, 0x82, 0x6e,
  0xcc, 0x56, 0x34, 0xfa, 0xf9, 0x3d, 0x10, 0xec, 0x8e, 0xf9, 0xb6, 0x9c, 0x23, 0xd3, 0x6a, 0xf5, 0x94, 0xa6, 0x89, 0x99,
  0x21, 0xec, 0x5c, 0xfd, 0x77, 0x78, 0x50, 0x77, 0x16, 0xb0, 0x1c, 0x03, 0x76, 0x0d, 0x8f, 0xda, 0x80, 0xda, 0xbb, 0x6c,
  0x9d, 0xcf, 0xaf, 0x8d, 0xc5, 0x96, 0x44, 0x4b, 0x24, 0x82, 0xb3, 0x3c, 0x98, 0xa0, 0x18, 0x66, 0x02, 0x31, 0xcc, 0x30,
  0x6d, 0x79, 0x20, 0xaf, 0xcd, 0x26, 0xee, 0xe1, 0x7d, 0x6f, 0x08, 0xcc, 0x59, 0x50, 0x14, 0x9f, 0x11, 0xa4, 0xb3, 0xbf,
  0x3b, 0xc0, 0x69, 0xa1, 0xaf, 0xa4, 0x1c, 0xd5, 0xc1, 0xbb, 0xfe, 0x29, 0x55, 0x92, 0x44, 0xdf, 0x3a, 0x71, 0xa0, 0xeb,
  0x98, 0x46, 0x99, 0x86, 0x14, 0xef, 0x15, 0xa6, 0xb1, 0xf1, 0xa9, 0xea, 0x11, 0x39, 0xf2, 0xb1, 0xea, 0x8b, 0x50, 0x2a,
  0x89, 0x66, 0x27, 0x43, 0xab, 0xfe, 0x17, 0xc5, 0x72, 0xd9, 0xcb, 0xc0, 0x7d, 0x42, 0xb2, 0xf6, 0xc5, 0x85, 0x64, 0x3b,
  0x72, 0x78, 0xde, 0x9a, 0xb7, 0x11, 0xf4, 0x64, 0x7f, 0xdb, 0xf1, 0xe7, 0xe4, 0xf6, 0x22, 0x26, 0x8d, 0xdd, 0xe7, 0x0a,
  0x55, 0x0f, 0xb7, 0x95, 0x4e, 0x7c, 0xfe, 0xd7, 0x4d, 0x2d, 0x68, 0xff, 0x9b, 0x48, 0x43, 0x4b, 0x42, 0xb1, 0xe3, 0x78,
  0x1d, 0x35, 0xb5, 0xf6, 0x93, 0xb5, 0x19, 0x7c, 0x3c, 0x7f, 0xab, 0x2a, 0x36, 0xba, 0x7a, 0x5b, 0x4c, 0xb1, 0x25, 0x21,
  0x9b, 0x11, 0x47, 0x1b, 0x23, 0x93, 0xa4, 0x26, 0xe3, 0x38, 0x8d, 0x9d, 0x7f, 0x31, 0x4a, 0x77, 0x1c, 0x68, 0x5b, 0xd4,
  0xd8, 0x95, 0x1f, 0x42, 0xe2, 0xa6, 0x0c, 0xaf, 0x2d, 0xbe, 0x92, 0x7a, 0x08, 0x8f, 0xfd, 0x59, 0xaf, 0x0b, 0x17, 0xd9,
  0x12, 0x12, 0x44, 0x34, 0x8c, 0x3b, 0x3e, 0x51, 0x42, 0x83, 0x3b, 0xef, 0x1a, 0x96, 0x0b, 0x36, 0x39, 0x20, 0x19, 0x6a,
  0x32, 0x9a, 0x72, 0xcc, 0x6f, 0x56, 0x06, 0xb3, 0xe9, 0x47, 0xb9, 0xd5, 0x8d, 0xd8, 0xd7, 0xb5, 0xc5, 0xbe, 0xd8, 0x23,
  0x72, 0x72, 0x09, 0xa2, 0xff, 0xd9, 0xc4, 0x51, 0x55, 0x8f, 0x3c, 0xa5, 0x33, 0x3a, 0x8f, 0xd4, 0x57, 0x5b, 0x65, 0xc8,
  0x61, 0xc1, 0x1d, 0x4d, 0x9e, 0x9a, 0x22, 0xd7, 0xb4, 0x3e, 0x66, 0xe5, 0x10, 0x0e, 0xea, 0x28, 0x9c, 0x17, 0x4f, 0x6f,
  0x61, 0xee, 0x2c, 0x5f, 0x8d, 0x49, 0xf1, 0xad, 0x12, 0x12, 0xc1, 0xff, 0xba, 0x22, 0x36, 0xfc, 0x2d, 0xe5, 0xa2, 0xb1,
  0x55, 0x67, 0xf6, 0x30, 0xeb, 0x85, 0x3f, 0x2f, 0xd1, 0xb6, 0x60, 0x39, 0x92, 0x99, 0xb1, 0xe3, 0x18, 0x7e, 0xd0, 0x5f,
  0x90, 0x46, 0x76, 0x63, 0xc7, 0x18, 0x8e, 0xd0, 0xc7, 0x7b, 0x28, 0x4c, 0x90, 0x54, 0xe9, 0x6b, 0xb7, 0xdb, 0xb1, 0x09,
  0x7b, 0x98, 0xa5, 0xe9, 0xf1, 0x2d, 0xfc, 0xc1, 0xc1, 0xbd, 0xc0, 0x31, 0x86, 0xb8, 0x2f, 0x38, 0x47, 0x28, 0xa7, 0xc5,
  0x0a, 0xa9, 0x3e, 0x15, 0x85, 0x98, 0xd6, 0x3f, 0xa6, 0x58, 0x96, 0x80, 0x28, 0x87, 0xcf, 0x8a, 0xf9, 0x66, 0xb1, 0x2e,
  0x8f, 0xe0, 0x2f, 0x4c, 0x2d, 0x82, 0xff, 0x5f, 0x97, 0xab, 0xe5, 0xd1, 0xa3, 0x7f, 0x00, 0x8a, 0x61, 0xfd, 0x3f, 0xf2,
  0xb7, 0x01, 0x00,
};

static void sendIndexPage(void)
{
  server.sendHeader("Content-Encoding", "gzip");
  server.sendHeader("Cache-Control", "no-cache");
  server.send_P(200, PSTR("text/html"), (PGM_P)INDEX_HTML_GZ, sizeof(INDEX_HTML_GZ));
}
//...................................................................
// End of file
// Firmware Version: V0.1 R1
